# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_TX_N0: length 3.7
  TOP w0.112: CI3.2 18.78,96.3 18.35,96.3 v1(18.18,96.47) 18,96.29 17.86,96.29 17.72,96.43 LI2.2 17.24,96.6 RI2.1
  BOTTOM w0.112: RI21.1 18.92,96.16 18.49,96.16 v1(18.18,96.47)
HDMI_TX_N1: length 3.5
  TOP w0.112: RI12.1 17.24,92.6 LI4.2 17.72,92.43 17.86,92.29 17.99,92.29 18.18,92.47 v1(18.18,92.47) 18.18,92.47 18.38,92.27 18.81,92.27 CI5.2
  BOTTOM w0.112: RI17.1 18.7,92.21 18.44,92.21 v1(18.18,92.47)
HDMI_TX_N2: length 3.6
  TOP w0.112: CI7.2 19.17,90.58 18.93,90.34 18.38,90.34 v1(18.18,90.54) 17.98,90.34 17.79,90.34 17.67,90.46 LI3.2 17.24,90.63 RI11.1
  BOTTOM w0.112: RI19.1 18.77,90.37 18.35,90.37 v1(18.18,90.54)
HDMI_TX_P0: length 3.6
  TOP w0.112: CI4.2 18.82,96.08 18.37,96.08 v1(18.18,95.89) 18,96.07 17.86,96.07 17.72,95.93 LI2.3 17.24,95.76 RI6.1
  BOTTOM w0.112: v1(18.18,95.89) 18.23,95.94 18.96,95.94 RI22.1
HDMI_TX_P1: length 3.4
  TOP w0.112: 18.18,91.89 18.34,92.05 18.79,92.05 CI6.2 ; 18.18,91.89 v1(18.18,91.89) ; 18.18,91.89 18,92.07 17.85,92.07 17.72,91.93 LI4.3 17.24,91.76 RI8.1
  BOTTOM w0.112: RI18.1 18.77,91.99 18.28,91.99 v1(18.18,91.89)
HDMI_TX_P2: length 3.5
  TOP w0.112: RI7.1 17.24,89.79 LI3.3 17.61,89.96 17.76,90.12 18.02,90.12 v1(18.18,89.96) 18.34,90.12 18.96,90.12 19.17,89.91 CI8.2
  BOTTOM w0.112: RI20.1 18.71,90.15 18.37,90.15 v1(18.18,89.96)
HOST_DEBUG_TX: length 68.7
  TOP w0.112: JDEG1.8 40.25,96.65 v1(39.35,95.75) 38.83,95.24 RE51.2 ; UE1.81 43.35,82.51 v1(41.37,80.53) ; RW4.2 62.82,127.06 v2(61.92,127.06) v1(61.92,126.55)
  IN1 w0.119: v1(39.35,95.75) 39.35,96.94 40.38,97.98 44.35,97.98 45.9,99.53 48.36,99.53 50.4,101.56 50.4,112.47 52.62,114.69 52.62,115.86 61.93,125.17 61.93,126.54 v1(61.92,126.55)
  IN2 w0.124: v1(39.35,95.75) 40.28,94.82 40.28,92.4 41.44,91.24 41.44,88.07 41.12,87.75 41.12,83.23 41.76,82.58 41.76,81.38 41.37,80.99 v1(41.37,80.53)
HPOUT_L: length 14.2
  TOP w0.254: JHP1.1 13.12,7.42 v2(14.64,7.42) 15.15,7.42 16.99,9.27 17.81,9.27 18.08,9.53 DA6.2 v1(18.08,11.11) ; LA2.2 21.49,12.54 v1(21.12,12.54)
  BOTTOM w0.254: CA36.1 18.07,11.12 v1(18.08,11.11) ; CA36.1 18.78,11.98 19.02,11.74 20.23,11.74 20.99,12.5 21.12,12.5 v1(21.12,12.54) ; CA36.1 RA34.1
HPOUT_R: length 24.9
  TOP w0.254: LA3.2 21.47,10.74 v1(19.92,10.74) ; v1(17.18,11.11) 17.18,10.79 16.38,9.99 DA6.3 16.15,11.11 v1(16.59,11.55)
  BOTTOM w0.254: v1(19.92,10.74) 18.71,10.74 18.27,10.3 RA33.1 CA35.1 v1(17.18,11.11) ; v1(16.59,11.55) 16.15,11.99 16.15,17.03 14.7,18.47 8.73,18.47 7.66,17.4 JHP1.2
HW_ACAV_IN: length 248.6
  TOP w0.112: UE1.128 34.93,69.41 34.82,69.3 34.82,68.65 35.24,68.24 v1(35.24,68.18) 34.83,67.78 34.83,66.8 34.76,66.72 CE32.2 v2(34.76,65.11)
  TOP w0.254: PRB25.2 205.53,48.06 205.61,47.99 PRB22.2 206.03,47.19 PRB26.1 206.29,47.18 206.54,47.42 PR31.1 207.65,47.42 v1(208.04,47.03)
  IN2 w0.124: v1(208.04,47.03) 208.07,47.07 208.07,47.43 209.15,48.51 211.34,48.51 212.32,47.54 212.32,46.31 212.95,45.68 215.07,45.68 215.81,46.41 216.52,46.41 217.5,45.43 217.5,42.6 216.73,41.83 214.58,41.83 211.79,39.04 211.79,37.83 211.39,37.43 207.6,37.43 206.96,38.06 206.64,38.06 205.46,36.88 197.71,36.88 196.22,35.39 173.54,35.39 172.13,33.97 164.44,33.97 163.71,33.24 146.55,33.24 145.56,34.23 134.55,34.23 131.48,31.16 118.16,31.16 117.63,31.68 115.83,31.68 115.43,31.29 97.43,31.29 95.65,29.51 95.65,28.16 95.39,27.91 94.23,27.91 94.04,27.91 92.9,29.05 90.05,29.05 88.86,27.87 85.96,27.87 84.87,28.95 71.66,28.95 71.08,28.37 68.33,28.37 68.16,28.54 66.15,28.54 65.54,27.93 61.71,27.93 60.55,29.09 60.09,29.09 54.87,34.31 50.59,34.31 45.72,39.17 45.72,47.6 45.33,48 45.33,53.62 46.06,54.35 46.06,58.5 42.57,61.99 41.69,61.99 40.05,63.63 39.36,63.63 38.75,64.24 37.23,64.24 36.61,64.86 36.61,66.81 v1(35.24,68.18)
I2C_0_SCL: length 32.8
  TOP w0.112: R37.2 117.51,29.65 117.62,29.54 Q10.1 118.31,29.54 118.42,29.65 118.42,29.72 119.22,30.52 123.51,30.52 128.31,35.33 v1(128.31,38.29)
  IN3 w0.135: v1(128.31,38.29) 128.94,37.66 128.94,37.65 129.19,37.4 131.07,37.4 131.59,37.92 131.59,40.46 131.49,40.57 131.49,45.7 130.84,46.35 130.84,46.37 130.54,46.67 130.52,46.67 130.45,46.74 v1(130.32,46.74)
  BOTTOM w0.076: v1(130.32,46.74) 130.14,46.74 129.73,47.15 129.73,47.46 130.04,47.77 130.04,47.79 130.05,47.8 130.05,48.11 130.04,48.14 130.04,48.14 130.01,48.23 130.01,48.41 130.13,48.73 UC1.CN11
I2C_0_SCL_R: length 5.8
  TOP w0.112: v1(119.32,29.35) 119.49,29.35 119.68,29.54 Q10.6 v2(121.01,29.54) 122.66,29.54 123.34,28.85 R43.2
  BOTTOM w0.112: v1(119.32,29.35) 120.05,30.08 JTP1.6
I2C_0_SDA: length 35.1
  TOP w0.112: v1(128.88,38.41) 128.88,35.2 123.71,30.03 119.42,30.03 118.91,29.52 118.91,28.88 119.22,28.57 119.65,28.57 Q10.4 119.98,28.04 120.09,27.93 v2(120.96,27.93) 122.56,27.93 R36.2
  IN3 w0.135: v1(128.88,38.41) 129.35,38.41 129.73,38.03 130.97,38.03 131.33,38.39 131.33,40.35 131.23,40.46 131.23,43.86 131.04,44.05 131.04,45.42 130.32,46.14 v1(130.32,46.16)
  BOTTOM w0.076: UC1.CM11 130.54,49.35 130.54,48.89 130.5,48.76 130.5,48.52 130.54,48.41 130.54,48.23 130.5,48.11 130.5,47.21 130.68,47.03 130.68,46.51 v1(130.32,46.16)
I2C_0_SDA_R: length 5
  TOP w0.112: R45.2 116.38,28.24 v2(117.13,28.24) Q10.3 118.73,28.24 v1(118.78,28.28)
  BOTTOM w0.112: v1(118.78,28.28) 118.78,29.78 119.05,30.05 JTP1.7
I2C_1_SCL: length 115.2
  TOP w0.112: R87.2 206.84,40.36 R85.1 204.7,40.44 v1(204.29,40.85)
  IN1 w0.119: v1(135.42,27.56) 135.61,27.36 137.42,27.36 139.98,29.93 143.97,29.93 145.1,28.79 149.8,28.79 150.56,28.03 158.2,28.03 159.22,29.05 171.6,29.05 172.96,27.69 173.37,27.28 174.25,27.28 174.81,27.84 175.93,27.84 180.94,32.85 188.27,32.85 191.3,35.87 197.39,35.87 199.55,38.03 204.88,38.03 205.27,38.41 205.39,38.54 205.39,39.17 204.29,40.28 v1(204.29,40.85)
  IN3 w0.089: v1(129.08,51.06) 129.01,51.06 128.7,50.75 128.7,50.33 128.93,50.1 128.95,50.1 129.06,50.03 129.12,49.92 129.1,49.21 ; 129.63,48.77 129.55,48.77
  IN3 w0.135: v1(131.97,36.25) 131.97,37.13 132.11,37.26 132.11,40.68 132,40.78 132,45.87 132.08,45.94 132.08,46.8 131.78,47.09 131.31,47.09 129.63,48.77 ; 129.55,48.77 129.42,48.77 129.1,49.09 129.1,49.21
  BOTTOM w0.076: v1(129.08,51.06) 129.12,51.13 UC1.CJ12
  BOTTOM w0.112: v1(131.97,36.25) 131.99,36.25 132.82,35.41 135.91,35.41 137.38,33.95 137.38,31.43 135.16,29.21 135.16,27.81 v1(135.42,27.56)
I2C_1_SDA: length 114.4
  TOP w0.112: R86.2 206.84,41.3 R84.1 206.5,40.95 v2(205.25,40.95) 204.94,40.95 204.55,41.33 203.9,41.33 v1(203.4,40.83)
  IN1 w0.119: v1(135.8,28) 137.34,28 139.76,30.41 144.19,30.41 145.31,29.29 149.59,29.29 149.6,29.29 150.01,29.29 150.77,28.53 158.26,28.53 159.06,29.32 171.68,29.32 173.46,27.54 174.15,27.54 174.71,28.1 175.82,28.1 178.48,30.75 178.48,31.06 180.52,33.11 188.15,33.11 191.17,36.13 197.26,36.13 199.42,38.29 204.76,38.29 205.14,38.67 205.14,39.04 203.4,40.78 v1(203.4,40.83)
  IN3 w0.089: v1(129.07,50.48) 129.1,50.48 129.3,50.28 129.3,49.47 130,48.77 130,48.77
  IN3 w0.135: v1(132.5,36.51) 132.37,36.63 132.37,40.78 132.26,40.89 132.26,45.76 132.34,45.83 132.34,47.08 131.99,47.43 131.99,47.68 131.72,47.95 130.83,47.95 130.18,48.6 130.17,48.6 130,48.77
  BOTTOM w0.076: UC1.CK12 v1(129.07,50.48)
  BOTTOM w0.112: v1(135.8,28) 135.8,29.01 137.87,31.09 137.87,34.15 136.12,35.9 133.1,35.9 v1(132.5,36.51)
I2C_3_SCL: length 54.2
  TOP w0.112: RC183.2 118.77,47.54 118.77,47.12 119.13,46.76 v1(119.14,46.76) 119.46,46.44 119.46,46.01 118.96,45.51 118.96,34.82 119.33,34.45 v1(119.54,34.45)
  IN3 w0.135: v1(119.54,34.45) 120.06,33.93 121.23,33.93 122.08,33.08 124.39,33.08 126.99,35.68 130.81,35.68 131.58,34.91 140.15,34.91 v1(140.79,35.55)
  BOTTOM w0.076: UC1.CH28 119.88,51.71 119.88,50.59 119.34,50.05 119.34,49.14 119.28,49.08 119.28,47.84 119.51,47.61 119.51,47.09 119.18,46.76 v1(119.14,46.76)
  BOTTOM w0.112: JDB1.10 147.28,36.2 147.1,36.38 147.1,38.29 146.85,38.54 143.55,38.54 141,35.99 141,35.85 140.79,35.63 v1(140.79,35.55)
I2C_3_SDA: length 50.4
  TOP w0.112: v1(120.2,34.44) 119.79,34.04 119.41,34.04 118.72,34.73 118.72,45.82 v1(119.07,46.17) 118.47,46.77 118.47,47.07 RC182.2
  IN3 w0.135: v1(141.36,35.64) 140.99,36.02 140.69,36.02 139.85,35.17 131.69,35.17 130.92,35.94 126.89,35.94 124.28,33.34 122.19,33.34 121.34,34.19 120.45,34.19 v1(120.2,34.44)
  BOTTOM w0.076: UC1.CH27 120.16,51.56 120.44,51.28 120.44,50.74 120.05,50.35 120.05,49.87 119.91,49.73 119.91,49.5 120.05,49.36 120.05,49.23 119.93,49.12 119.93,48.95 119.88,48.75 119.83,48.6 119.78,48.47 119.77,48.44 119.77,48.18 119.85,47.99 119.85,47.86 119.68,47.69 119.68,46.71 119.13,46.17 v1(119.07,46.17)
  BOTTOM w0.112: JDB1.9 144.48,36.2 143.93,35.65 141.37,35.65 v1(141.36,35.64)
I_ADP: length 6.7
  TOP w0.112: UE1.110 34.91,76.61 34.52,76.22 32.93,76.22 32.72,76.43 v2(31.25,76.43) 30.87,76.43 30.72,76.27 CE26.1 RE46.1
I_ADP_R: length 257.6
  TOP w0.112: v1(30.53,79.59) 30.53,78.38 RE46.2 ; v1(44.31,107.37) 44.3,107.37 44.1,107.37 40.36,103.63 40.36,102.93 v1(40.17,102.74) ; v1(187.98,62.66) 188.25,62.66 v2(188.54,62.95)
  TOP w0.254: PRB32.2 v1(211.22,45.32)
  IN2 w0.124: v1(44.31,107.37) 43.98,107.04 43.98,105.74 44.61,105.11 45.01,105.11 46.39,106.48 49.3,106.48 56.49,113.67 85.45,113.67 87.46,111.65 113.09,111.65 114.97,113.52 119.38,113.52 120.32,112.59 122.46,112.59 122.98,112.07 128.75,112.07 131.55,109.27 135.17,109.27 139.32,105.12 143.26,105.12 143.89,105.75 157.16,105.75 168.24,94.67 168.24,88.96 168.75,88.45 168.75,76.64 173.38,72.01 180.61,72.01 181.7,70.92 181.7,67.95 186.99,62.66 v1(187.98,62.66) ; v1(30.53,79.59) 31.06,80.12 33.15,80.12 33.78,80.75 33.78,89.6 36.38,92.21 36.38,98.96 v1(40.17,102.74)
  IN3 w0.135: v1(187.98,62.66) 188.12,62.8 191.93,62.8 193.46,61.27 197.01,61.27 197.43,61.7 197.94,61.7 199.12,60.51 201,60.51 209.89,51.62 210.69,51.62 211.9,50.41 211.9,46 v1(211.22,45.32)
I_BATT: length 8
  TOP w0.112: v2(29.13,75.38) 29.6,74.91 31.63,74.91 RE47.1 32.11,74.48 CE31.1 34.37,75.37 34.74,75.01 UE1.114
I_BATT_R: length 247.8
  TOP w0.112: RE47.2 30.82,74.46 v1(30.56,74.2) ; v1(217.95,46.07) v2(218.55,46.07)
  IN1 w0.119: v1(211.5,47.11) 212.52,47.11 213.79,45.84 214.66,45.84 215.01,46.19 217.83,46.19 v1(217.95,46.07)
  IN2 w0.124: v1(217.95,46.07) 217.95,42.42 216.92,41.38 214.77,41.38 212.24,38.85 212.24,37.64 211.48,36.88 207.84,36.88 207.16,36.2 198.63,36.2 197.9,35.48 197.9,35.24 197.37,34.71 173.95,34.71 172.53,33.3 164.77,33.3 164.04,32.56 146.27,32.56 145.28,33.55 134.83,33.55 131.76,30.48 117.87,30.48 117.35,31 116.1,31 115.71,30.61 97.71,30.61 96.33,29.22 96.33,27.88 95.63,27.19 68.87,27.19 67.97,28.09 66.34,28.09 65.73,27.48 61.53,27.48 60.37,28.64 59.9,28.64 54.68,33.85 50.4,33.85 44.9,39.35 44.9,53.51 45.83,54.44 45.83,58.41 42.48,61.76 41.6,61.76 39.96,63.4 39.27,63.4 38.66,64.01 37.14,64.01 34.51,66.63 34.51,73.34 33.66,74.2 v1(30.56,74.2)
  BOTTOM w0.254: PCB10.1 PRB29.1 v1(211.5,47.11)
I_SYS: length 43.2
  TOP w0.112: PRZ11.2 179.28,54.78 v2(180.22,54.78)
  TOP w0.254: PRB33.2 210.09,44.08 210.54,44.08 v1(210.93,43.68) ; v1(179.68,53.63) 179.43,53.63 179.02,54.04 PRZ11.2
  IN3 w0.254: v1(210.93,43.68) 210.93,44.68 210.74,44.86 210.74,44.89 209.4,46.22 207.23,46.22 203.87,49.59 202.53,49.59 201.53,48.58 201.13,48.58 201.13,48.58 200.96,48.58 200.31,47.94 197.89,47.94 197.38,48.45 196.98,48.45 186.34,48.45 181.15,53.63 v1(179.68,53.63)
  BOTTOM w0.203: PUZ01.46 178.9,54.5 179.53,53.86 179.53,53.79 179.69,53.63 v1(179.68,53.63)
ICCMAX_1A_CPU: length 3.7
  TOP w0.112: v1(171.07,56.2) 170.48,56.2 v2(169.94,55.66)
  TOP w0.254: PRZ67.1 171.32,56.05 171.22,56.05 v1(171.07,56.2)
  BOTTOM w0.203: v1(171.07,56.2) 171.17,56.1 PUZ01.19
ICCMAX_1B_CPU: length 2.9
  TOP w0.112: v1(171.07,56.78) 170.57,56.78 v2(170.47,56.88)
  TOP w0.254: v1(171.07,56.78) 171.48,56.78 PRZ68.1
  BOTTOM w0.203: v1(171.07,56.78) 171.26,56.78 171.55,56.5 PUZ01.20
ICCMAX_2PH_CPU: length 4.1
  TOP w0.112: v2(170.46,54.45) 170.46,55.19 170.89,55.61 v1(171.07,55.61)
  TOP w0.254: v1(171.07,55.61) 171.28,55.4 171.28,55.2 PRZ66.1
  BOTTOM w0.203: v1(171.07,55.61) 171.15,55.7 PUZ01.18
ICSP_CLK: length 3
  TOP w0.112: UE1.101 34.91,80.21 34.13,80.98 34.13,81.66 34.01,81.78 RE53.2
ICSP_CLR: length 4.8
  TOP w0.112: v2(40.89,87.78) 40.45,87.33 40.45,86.53 40.72,86.25 RE54.2 40.95,86.1 UE1.87
ICSP_DAT: length 2.9
  TOP w0.112: UE1.102 34.51,79.81 v2(34.16,80.16) 33.73,80.59 RE55.2
ILIM_1A_CPU: length 4.9
  TOP w0.112: v1(173.22,60.41) 173.22,60.58 v2(173.48,60.84)
  TOP w0.254: v1(173.22,60.41) 173.22,60.21 173.47,59.95 174.02,59.95 174.28,59.7 PRZ56.1 PCZ32.1
  BOTTOM w0.203: v1(173.22,60.41) 173.22,60.19 174.03,59.38 PUZ01.27
ILIM_1B_CPU: length 5.7
  TOP w0.112: PRZ05.1 179.03,55.4 179.33,55.1 181.2,55.1 v2(181.57,54.73)
  TOP w0.254: PRZ05.1 PCZ05.1 179.62,56.24 v1(179.76,56.1)
  BOTTOM w0.203: v1(179.76,56.1) PUZ01.42
ILIM_2PH_CPU: length 2.8
  BOTTOM w0.203: PRZ28.2 v2(176.03,51.61) PUZ01.5
ILMT_1.05V: length 3.5
  TOP w0.112: v1(163.48,43.29) 163.22,43.56 v2(163.22,43.92)
  TOP w0.254: v1(163.48,43.29) 163.48,43.24 163.93,42.79 PRH04.1 PRH03.2
  BOTTOM w0.254: v1(163.48,43.29) 163.48,43.37 163.13,43.72 PUH01.12
IMON_VGA: length 5.5
  TOP w0.203: PUV01.10 71.11,127.9 71.05,127.84 68.67,127.84 v2(68.23,128.28) 68.12,128.39 PCV20.1 PRV16.1
IMVP_VR_ON: length 141.9
  TOP w0.112: v1(91.41,43.37) 91.41,43.49 92.05,44.13 RC148.2 ; v1(161.83,36.58) v2(161.83,36.08)
  IN1 w0.119: v1(161.83,36.58) 162.96,35.46 170.31,35.46 172.12,37.27 172.12,40.53 175.12,43.53 176.13,44.54 176.13,46.55 176.63,47.05 176.95,47.05 177.46,47.57 177.97,47.57 178.95,48.54 178.95,49.52 180.25,50.82 180.25,55.23 180.5,55.49 v1(180.5,60)
  IN2 w0.124: v1(85.76,31.3) 87.09,32.63 94.26,32.63 95.68,34.05 117.85,34.05 119.14,35.34 119.88,35.34 120.04,35.5 132.62,35.5 133.85,36.73 135.45,36.73 135.92,36.25 138.9,36.25 142.07,39.43 142.9,39.43 144.27,38.06 146.65,38.06 146.94,37.78 151.97,37.78 153.97,35.78 161.03,35.78 v1(161.83,36.58)
  BOTTOM w0.112: PRZ22.2 180.76,59.75 v1(180.5,60) ; v1(85.76,31.3) 85.76,31.47 84.86,32.36 84.86,35.7 83.38,37.19 83.25,37.31 83.25,38.12 84.44,39.3 86.64,39.3 86.78,39.43 88.12,39.43 90.12,41.42 91.41,42.72 v1(91.41,43.37)
INPUT3VSEL: length 18.1
  TOP w0.112: RC103.2 103.76,60.97 105.44,60.97 RC104.1 v2(110.09,60.51) 110.65,60.51 111.15,60.02 115.79,60.02 116.4,59.4 116.99,59.4 117.09,59.3 119.48,59.3 v1(119.87,58.91)
  BOTTOM w0.089: UC1.BT27 120.07,59.22 v1(119.87,58.91)
INT_TP#: length 13.4
  TOP w0.112: v1(123.54,29.52) 124.49,30.48 128.75,30.48 129.19,30.92 129.19,31.42 Q8.3 v2(132,32.39) 132,31.52 R42.2
  BOTTOM w0.112: JTP1.4 122.05,29.68 122.27,29.46 123.48,29.46 v1(123.54,29.52)
INTRUDER#: length 6.1
  BOTTOM w0.076: UC1.BR35 114.9,59.91 114.45,59.91 114.22,59.94 114.08,60.02 112.18,60.02 v2(111.99,59.83) 111.86,59.7 109.7,59.7 RC87.2
IO_CBL_DET#: length 133.9
  TOP w0.112: v1(147.35,31.55) 146.59,31.55 144.5,33.65 v2(141.97,33.65) 134.4,33.65 132.81,35.24 131.35,35.24 129.27,37.32 129.27,38.57 129.04,38.8 128.21,38.8 127.33,37.92 v1(127.11,37.92) ; v1(204.89,35.75) 205.14,36 R92.2
  IN1 w0.119: v1(204.89,35.75) 206.16,37.02 206.16,39.94 204.67,41.43 202.48,41.43 200.87,39.81 200.31,39.81 197.14,36.63 191.2,36.63 187.92,33.35 180.42,33.35 178.23,31.16 178.23,30.85 175.72,28.34 174.6,28.34 174.05,27.78 173.57,27.78 171.79,29.57 159.31,29.57 155.64,33.24 149.89,33.24 148.21,31.55 v1(147.35,31.55)
  IN2 w0.124: v1(127.11,37.92) 126.11,37.92 125.33,37.14 121.7,37.14 121.32,37.52 119.07,37.52 117.54,36 v1(115.86,36)
  IN3 w0.135: v1(123.75,47.35) 124.44,47.35 125.26,46.54 125.26,42.68 124.67,42.09 121.57,42.09 120.05,40.57 118.65,40.57 115.86,37.78 v1(115.86,36)
  BOTTOM w0.076: UC1.CM23 123.45,49.62 123.69,49.38 123.69,47.41 v1(123.75,47.35)
  BOTTOM w0.112: v1(204.89,35.75) 205.2,36.06 JIOB1.9
IOUT_1A_CPU: length 4.8
  TOP w0.112: PRZ50.1 v2(177.86,59.44)
  TOP w0.254: PRZ50.1 PCZ25.1 175.99,59.56 175.2,60.35 v1(175,60.35)
  BOTTOM w0.203: v1(175,60.35) 175,59.84 175.23,59.61 PUZ01.30
IOUT_1B_CPU: length 3.7
  TOP w0.112: v2(179.94,58.03) 179.94,57.72 v1(179.72,57.5)
  TOP w0.254: v1(179.72,57.5) 179.35,57.13 PRZ15.1 PCZ12.1
  BOTTOM w0.203: v1(179.72,57.5) 179.31,57.5 179.11,57.3 PUZ01.39
IOUT_2PH_CPU: length 3.7
  TOP w0.112: v1(178.42,52.32) 178.68,52.07 v2(178.95,52.07)
  TOP w0.254: v1(178.42,52.32) PRZ23.1 177.23,52.32 177.2,52.29 PCZ14.1
  BOTTOM w0.203: PUZ01.1 177.63,52.59 177.89,52.32 v1(178.42,52.32)
ISEN1_VGA: length 16.3
  TOP w0.112: v2(73.03,117.97) 72.86,117.97 71.57,119.26 70.94,119.26 70.86,119.34 PRV22.2
  TOP w0.203: PUV01.13 73.18,126.74 72.44,126 71.23,126 71.01,125.79 PCV23.1
  TOP w0.254: PCV23.1 70.66,125.8 70.1,126.36 v1(69.25,126.36) ; v1(69.62,119.25) 69.71,119.34 PRV22.2
  IN2 w0.254: v1(69.62,119.25) 69.63,119.26 69.63,121.4 69.25,121.78 v1(69.25,126.36)
ISEN2_VGA: length 12.5
  TOP w0.203: PCV22.1 68.28,126.69 v1(68.61,126.36) 69.1,126.84 v2(70.48,126.84) 70.79,126.84 71.28,126.35 72.35,126.35 72.78,126.78 PUV01.12
  TOP w0.254: v1(69.11,121.21) 69.1,121.21 69,121.12 68.46,121.12 PRV03.2
  IN2 w0.254: v1(68.61,126.36) 68.61,121.61 69.02,121.21 v1(69.11,121.21)
ISOLATE#: length 5.4
  TOP w0.112: UL1.20 24.4,84.7 24.61,84.92 24.61,86.29 RL8.2 24.14,86.76 24.14,87.52 RL9.1 24.62,88.88 v2(24.86,89.12)
IST_TRIG: length 6
  BOTTOM w0.112: TP32.1 112.63,45.2 112.63,46.23 113.32,46.92 113.32,48.38 113.73,48.79 114.37,48.79 UC1.CP36
JACK_PLUG: length 23.8
  TOP w0.254: v1(18.08,18.4) DA7.3 17.9,17.24 v1(17.11,18.03) ; v1(31.67,19.88) 32.22,19.88 32.35,19.74 RA14.1
  IN3 w0.254: v1(17.11,18.03) 13.28,18.03 JHP1.5 ; v1(31.67,19.88) 31.34,19.88 30.69,19.24 28.74,19.24 26.96,17.46 18.51,17.46 18.08,17.89 v1(18.08,18.4)
JACK_PLUG_DET: length 8.9
  TOP w0.254: RA35.1 16.15,15.62 DA7.2 14.98,18.41 v3(14.42,18.41) 10.91,18.41 JHP1.6
JTAG_CLK: length 2.4
  TOP w0.112: RE92.2 42.77,95.18 42.25,95.7 v2(42.25,95.89) JDEG1.4
JTAG_TCK: length 7.6
  TOP w0.112: v1(128.18,120.32) 128.18,119.9 RV19.1 127.99,119.59 127.4,119.01 127.4,118.7 126.98,118.28 126.63,118.28 v3(125.74,117.39)
  BOTTOM w0.102: 127.67,122.19 127.67,122.59 128.14,123.06 UV1.L3
  BOTTOM w0.112: 127.67,122.19 127.67,121.6 128.18,121.09 v1(128.18,120.32)
JTAG_TDI: length 24.1
  TOP w0.112: v1(32.55,81.85) 32.71,81.85 32.77,81.78 RE53.1 ; JDEG1.2 43.25,96.26 v2(43.53,95.98) 43.83,95.68 v1(43.83,95.57) 44.29,95.1 RE90.2
  IN3 w0.135: v1(32.55,81.85) 32.67,81.97 32.67,84.39 35.25,86.96 37.5,86.96 38.66,88.13 38.66,89.55 39.31,90.2 41.29,90.2 43.21,92.13 43.21,94.95 v1(43.83,95.57)
JTAG_TDI_GPU: length 9.7
  TOP w0.112: v1(128.32,117.18) v3(129.16,117.18)
  BOTTOM w0.102: UV1.L5 128.45,123.89 128.45,123.22 128.43,123.21 128.43,122.79 128.45,122.77 128.45,122.47 128.21,122.24
  BOTTOM w0.112: 128.21,122.24 128.21,121.71 128.82,121.1 128.82,118.94 128.6,118.72 128.6,117.47 v1(128.32,117.18) 127.86,116.72 RP34.7
JTAG_TDO: length 25.3
  TOP w0.112: RE93.2 41.75,95.2 v1(41.75,95.69) JDEG1.5 ; v2(31.89,82.63) 31.89,82.19 32.15,81.93 32.15,81.54 32.48,81.21 v1(32.55,81.21) 33.08,81.21 RE55.1
  IN3 w0.135: v1(32.55,81.21) 32.15,81.61 32.15,82.01 32.44,82.3 32.44,84.5 35.14,87.2 37.4,87.2 38.43,88.23 38.43,89.65 39.22,90.44 40.42,90.44 41.5,91.52 41.5,95.44 v1(41.75,95.69)
JTAG_TDO_GPU: length 11.2
  TOP w0.112: v3(131.25,117.17) 130.65,117.76 v1(129,117.76)
  BOTTOM w0.102: 129.49,119.27 129.03,119.73 129.03,121.19 128.96,121.26 ; UV1.K4 128.71,123.57 128.71,123.2 128.64,123.12 128.64,122.87 128.65,122.86 128.65,122.32 128.51,122.19
  BOTTOM w0.112: 128.96,121.26 128.44,121.78 128.44,122.11 128.51,122.19 ; RP34.8 128.36,116.53 129,117.17 v1(129,117.76) 129.49,118.25 129.49,119.27
JTAG_TMS: length 13
  TOP w0.112: RE91.2 43.53,95.12 43.04,95.6 v1(43.02,95.6) 43.02,95.62 42.75,95.9 JDEG1.3 ; v1(43.66,89.34) v2(43.19,88.87) 42.64,88.32 42.2,88.32 40.8,86.93 RE54.1
  IN2 w0.124: v1(43.02,95.6) 43.4,95.22 43.4,89.59 v1(43.66,89.34)
JTAG_TMS_GPU: length 8.3
  TOP w0.112: v3(127.43,116.99) v1(128.2,117.76)
  BOTTOM w0.102: UV1.L1 127.99,122.44 127.99,122.19
  BOTTOM w0.112: 127.99,122.19 127.99,121.63 128.57,121.05 128.57,118.99 128.39,118.81 128.39,117.95 v1(128.2,117.76) 128.2,117.7 127.36,116.86 RP34.6
JTAG_TRSTB: length 11.9
  TOP w0.112: v3(126.81,118.78) 127.05,119.02 127.05,119.77 v1(127.59,120.32)
  BOTTOM w0.102: 127.42,122.19 127.42,122.62 127.72,122.92 127.72,124.25 128.14,124.68 UV1.L6
  BOTTOM w0.112: 127.42,122.19 127.46,122.15 127.46,120.45 v1(127.59,120.32) 128.3,119.61 128.3,119.03 128.18,118.9 128.18,118.28 127.66,117.77 127.66,117.69 126.86,116.89 RP34.5
KB_BL_CTRL#: length 13
  TOP w0.127: v3(91.82,41.4) 92.16,41.4 93.1,40.46 Q7.1
  TOP w0.254: Q7.1 95.2,39.56 v1(95.3,39.45)
  BOTTOM w0.254: JKBBL1.4 91.72,34.52 90.97,35.28 90.97,36.3 91.18,36.51 92.54,36.51 95.3,39.27 v1(95.3,39.45)
KB_DET#: length 92
  TOP w0.112: v1(90.14,27.81) v2(89.59,27.81)
  IN3 w0.135: v1(90.14,27.81) 97.17,34.84 117.39,34.84 117.41,34.86 119.45,36.9 125.28,36.9 126.92,38.54 127.39,38.54 128.14,39.29 130.84,39.29 131.07,39.52 131.07,40.25 130.96,40.35 130.96,43.75 130.78,43.94 130.78,45.12 130.33,45.57 v1(130.32,45.57)
  BOTTOM w0.076: RC110.2 130.39,45.14 130.32,45.2 v1(130.32,45.57) 129.83,46.07 129.83,46.82 129.56,47.08 129.56,47.53 129.88,47.84 129.88,47.86 129.89,47.87 129.89,48.08 129.88,48.11 129.88,48.11 129.86,48.16 129.86,48.16 129.85,48.2 129.85,48.44 129.94,48.71 129.98,49.18 129.98,49.67 UC1.CM12
  BOTTOM w0.112: JKB1.1 59.75,33.43 60.08,33.11 73.55,33.11 79,27.66 89.99,27.66 v1(90.14,27.81)
KB_LED_BL_DET: length 30.8
  TOP w0.112: v1(100.76,44.38) v2(100.76,43.87)
  IN1 w0.119: v1(113.13,49.74) 113.04,49.82 111.77,49.82 108.12,46.17 102.09,46.17 100.76,44.83 v1(100.76,44.38)
  BOTTOM w0.076: UC1.CK36 114.62,50.19 114.4,49.97 114.14,49.97 114.08,50.03 113.42,50.03 v1(113.13,49.74)
  BOTTOM w0.112: v1(100.76,44.38) 100.76,43.02 96.34,38.6 95.04,38.6 93.18,36.74 R38.1 R40.1
KB_LED_DET_C: length 2.6
  TOP w0.127: v1(94.05,35.3) 94.05,34.87 v3(94.51,34.41)
  BOTTOM w0.254: R38.2 94.05,35.96 v1(94.05,35.3) JKBBL1.2
KB_LED_PWM: length 89.9
  TOP w0.112: v1(91.4,40.85) 91.95,40.29 91.95,39.51 92.57,38.89 94.88,38.89 Q7.2 95.18,37.83 v2(94.32,36.97) ; UE1.44 49.48,73.81 48.67,74.61 46.11,74.61 v1(45.74,74.24)
  IN2 w0.124: v1(45.74,74.24) 45.47,73.97 45.47,71.24 46.32,70.4 46.32,67.38 49.68,64.01 49.68,62.74 50.16,62.26 50.16,57.67 51.74,56.09 51.74,47.94 53.86,45.82 53.86,42.94 56.18,40.62 58.32,40.62 61.73,37.21 71.25,37.21 71.85,37.81 75.85,37.81 76.14,37.52 78.72,37.52 81.16,39.95 82.11,39.95 82.23,40.08 85.68,40.08 85.77,39.99 90.53,39.99 v1(91.4,40.85)
KSI0: length 79.3
  TOP w0.112: RE66.2 33.51,82.72 v2(34.46,82.72) 34.65,82.53 34.65,81.67 34.92,81.41 UE1.98 36.58,81.41 36.86,81.69 v1(37.46,81.69)
  IN1 w0.119: v1(37.56,74.59) 41.42,74.59 v1(42.26,75.43)
  IN2 w0.124: v1(37.56,74.59) 37.37,74.59 37.19,74.42 36.61,74.42 36.1,74.93 36.1,80.35 36.48,80.72 37.12,80.72 37.46,81.06 v1(37.46,81.69)
  BOTTOM w0.112: v1(42.26,75.43) 42.26,74.84 41.77,74.34 41.77,71.2 41.18,70.61 41.18,68.33 43.11,66.39 43.11,62.29 45.23,60.18 45.23,46.88 45.88,46.22 45.88,42.32 47.85,40.35 54.75,40.35 56.28,38.82 59.24,38.82 61.46,36.59 64.12,36.59 66.15,34.56 JKB1.9
KSI1: length 74.9
  TOP w0.102: 36.3,81.01 UE1.99 34.95,81.01 34.95,81.01
  TOP w0.112: 34.95,81.01 34.4,81.56 34.4,81.86 34.06,82.2 33.16,82.2 RE67.2 32.7,82.58 32.34,82.94 32.34,83.34 32.56,83.55 32.56,83.97 v2(32.86,84.27) ; 36.3,81.01 36.85,81.01 v1(37.06,81.22)
  BOTTOM w0.112: v1(37.06,81.22) 37.58,81.22 41.55,77.25 41.55,71.28 40.59,70.32 40.59,67.25 39.73,66.39 39.73,65.66 39.44,65.38 39.44,65 44.59,59.86 44.59,43.01 48.73,38.87 55.45,38.87 55.63,38.87 56.1,38.39 59.06,38.39 61.29,36.17 63.37,36.17 64.55,34.98 JKB1.7
KSI2: length 53.5
  TOP w0.112: v2(38.74,62.73) 38.17,63.3 38.17,64.19 38.46,64.49 RE68.2 38.52,65.02 v1(38.63,65.13) 39.1,65.6 39.1,66.18 39.35,66.43 UE1.6
  BOTTOM w0.112: v1(38.63,65.13) 44.16,59.6 44.16,42.83 48.55,38.44 55.45,38.44 55.93,37.97 58.88,37.97 61.11,35.74 62.33,35.74 62.95,35.12 JKB1.5
KSI3: length 53.7
  TOP w0.112: RE69.2 39.15,65.08 39.44,65.38 39.44,65.38 39.7,65.63 39.7,65.81 v2(39.71,65.82) v1(40.11,66.23) 40.11,66.58 39.75,66.94 UE1.7
  BOTTOM w0.112: v1(40.11,66.23) 42.58,63.75 42.58,62.16 44.8,59.95 44.8,43.1 48.82,39.08 55.37,39.08 55.72,39.08 56.19,38.61 59.15,38.61 61.37,36.38 63.79,36.38 65.35,34.82 JKB1.8
KSI4: length 71.6
  TOP w0.112: v1(38.2,78.21) 38.2,78.94 37.8,79.33 36.95,79.33 36.63,79.01 UE1.104 34.6,79.01 34.5,79.1 33.24,79.1 32.97,78.82 RE73.2 32.71,78.83 32.33,79.21 v2(31.07,79.21)
  BOTTOM w0.112: v1(38.2,78.21) 38.97,78.21 39.72,77.47 39.72,75.76 41.09,74.39 41.09,71.42 40.16,70.49 40.16,67.42 39.3,66.56 39.3,65.84 39.05,65.59 38.5,65.59 38.24,65.34 38.24,64.97 38.52,64.7 38.76,64.7 43.95,59.51 43.95,42.74 48.46,38.22 55.37,38.22 55.84,37.75 58.8,37.75 62.15,34.4 JKB1.4
KSI5: length 70.5
  TOP w0.112: v1(37.61,78.92) 37.11,78.92 36.8,78.61 UE1.105 v2(33.92,78.61) 33.85,78.61 33.44,78.19 RE72.2
  BOTTOM w0.112: JKB1.6 63.75,35.09 62.88,35.95 61.2,35.95 58.97,38.18 56.02,38.18 55.54,38.65 48.64,38.65 44.37,42.92 44.37,59.77 39.23,64.92 39.23,65.47 39.51,65.75 39.51,66.47 40.37,67.34 40.37,70.41 41.3,71.33 41.3,77.2 39.58,78.92 v1(37.61,78.92)
KSI6: length 68
  TOP w0.112: v1(37.6,77.74) 37.53,77.81 UE1.107 34.87,77.81 v2(33.88,76.82) 33.54,76.82 32.8,77.55 RE71.2
  BOTTOM w0.112: v1(37.6,77.74) 38.21,77.74 39.5,76.45 39.5,75.6 40.76,74.34 40.76,73.21 39.92,72.37 39.92,67.49 39.09,66.65 39.09,65.93 38.96,65.8 38.41,65.8 38.03,65.43 38.03,64.89 38.43,64.49 38.55,64.49 43.73,59.3 43.73,42.65 48.38,38.01 55.28,38.01 55.75,37.54 58.71,37.54 61.35,34.9 JKB1.3
KSI7: length 78.2
  TOP w0.112: v1(38.25,77.15) 38.18,77.22 37.57,77.22 37.39,77.41 UE1.108 34.93,77.41 33.98,76.46 33.17,76.46 RE70.2 ; v1(39.02,49.14) v2(39.65,49.14)
  IN1 w0.119: v1(38.25,77.15) 37.57,77.15 36.64,76.23 31.25,76.23 28.26,73.24 28.26,65.37 33.28,60.36 33.28,57.43 34.17,56.55 34.17,51.56 36.04,49.69 38.48,49.69 v1(39.02,49.14)
  BOTTOM w0.112: JKB1.2 60.55,35.39 58.62,37.33 55.66,37.33 55.19,37.8 48.29,37.8 39.02,47.06 v1(39.02,49.14)
KSO0: length 67.1
  TOP w0.112: v1(44.82,62.95) 44.48,62.61 RE74.2 v2(43.38,61.95) ; v1(37.85,69.33) 37.75,69.24 UE1.2
  IN1 w0.119: v1(37.85,69.33) 37.9,69.27 38.37,69.27 40.45,71.36 42.12,71.36 v1(42.15,71.39)
  IN3 w0.135: v1(44.82,62.95) 44.48,63.28 44.48,64.87 41.11,68.24 41.11,70.6 41.91,71.39 v1(42.15,71.39)
  BOTTOM w0.112: v1(44.82,62.95) 44.82,62.94 45.97,62.94 46.01,62.89 46.02,62.89 46.16,62.75 46.16,62.75 49.26,59.65 49.26,50.72 54.8,45.18 54.8,43.01 57.08,40.74 60.03,40.74 61.15,39.62 63.81,39.62 65.17,38.26 67.06,38.26 69.26,36.07 72.1,36.07 73.35,34.82 JKB1.18
KSO1: length 57.6
  TOP w0.112: v1(41.6,69.27) 42.06,68.81 42.44,68.81 42.55,68.7 UE1.14 ; RE75.2 45.12,62.41 v1(45.23,62.53) 45.23,63.07 44.97,63.34 v2(44.45,63.34)
  IN3 w0.135: v1(41.6,69.27) 41.6,68.08 45.53,64.15 45.53,62.82 v1(45.23,62.53)
  BOTTOM w0.112: JKB1.16 71.75,34.73 70.84,35.64 69.44,35.64 69.08,35.64 66.89,37.84 64.99,37.84 63.63,39.2 60.97,39.2 59.86,40.31 56.9,40.31 54.37,42.84 54.37,45 48.83,50.54 48.83,58.92 45.23,62.52 v1(45.23,62.53)
KSO2: length 58.4
  TOP w0.112: UE1.15 42.95,68.6 41.69,69.86 v1(41.6,69.86) ; RE76.2 45.82,62.01 v1(45.82,62.49) 46.25,62.93 v2(46.25,63.17)
  IN3 w0.135: v1(41.6,69.86) 41.6,69.83 42,69.43 42,68.02 45.82,64.2 v1(45.82,62.49)
  BOTTOM w0.112: v1(45.82,62.49) 49.05,59.26 49.05,50.63 54.59,45.09 54.59,42.93 56.99,40.53 59.94,40.53 61.06,39.41 63.72,39.41 65.08,38.05 66.98,38.05 69.17,35.85 69.35,35.85 71.24,35.85 72.55,34.54 JKB1.17
KSO3: length 63.4
  TOP w0.112: v2(47.51,61.95) RE77.2 46.39,62.15 46.64,62.4 46.64,63.28 v1(46.23,63.69) ; v1(41.6,70.48) 41.6,70.41 43.35,68.66 UE1.16
  IN3 w0.135: v1(46.23,63.69) 46.17,63.75 46.17,64.18 42.24,68.12 42.24,69.85 v1(41.6,70.48)
  BOTTOM w0.112: v1(46.23,63.69) 45.68,64.24 44.93,64.24 44.39,63.7 44.39,62.82 48.62,58.6 48.62,50.45 54.16,44.91 54.16,42.75 56.81,40.1 59.77,40.1 60.88,38.98 63.54,38.98 64.9,37.62 66.8,37.62 68.99,35.43 69.53,35.43 70.28,35.43 70.95,34.76 JKB1.15
KSO4: length 68.5
  TOP w0.112: v2(55.15,67.74) 54.24,68.65 54.24,68.92 RE78.2 54.07,69.08 53.04,69.08 52.63,69.49 52.63,70.55 52.17,71.01 UE1.37 50.56,71.01 50.17,71.4 50.17,71.49 49.94,71.71 48.64,71.71 48.58,71.65 v1(47.68,71.65)
  BOTTOM w0.112: v1(47.68,71.65) 47.24,71.21 47.24,65.66 46.67,65.09 44.58,65.09 43.54,64.05 43.54,62.47 45.65,60.35 45.65,47.09 46.31,46.43 46.31,42.49 48.03,40.78 54.93,40.78 56.46,39.25 59.41,39.25 61.64,37.02 64.3,37.02 64.55,36.77 65.62,36.77 67.75,34.64 JKB1.11
KSO5: length 67.1
  TOP w0.112: RE79.2 54.06,69.43 v2(53.13,69.43) 52.84,69.72 52.84,70.89 52.32,71.41 UE1.38 50.61,71.41 50.09,71.93 48,71.93 v1(47.68,72.24)
  BOTTOM w0.112: v1(47.68,72.24) 47.02,71.58 47.02,65.75 46.58,65.3 44.49,65.3 43.33,64.14 43.33,62.38 45.44,60.27 45.44,46.98 46.1,46.33 46.1,42.4 47.94,40.56 54.84,40.56 56.37,39.03 59.33,39.03 61.55,36.81 64.21,36.81 64.46,36.56 64.99,36.56 66.95,34.6 JKB1.10
KSO6: length 67.9
  TOP w0.112: v1(48.07,69.97) 48.07,70.02 48.35,70.31 48.35,70.71 47.94,71.13 47.52,71.13 47.23,71.41 47.23,72.55 47.38,72.7 48.17,72.7 48.73,72.14 50.23,72.14 50.56,71.81 UE1.39 52.45,71.81 53.53,70.73 RE80.2 53.62,70.74 53.98,71.11 54.5,71.11 54.67,70.94 54.67,70.7 54.9,70.46 55.08,70.46 55.9,69.64 v2(55.9,69.36)
  BOTTOM w0.112: JKB1.13 69.35,34.47 66.62,37.2 64.73,37.2 64.47,37.45 61.82,37.45 59.59,39.67 56.63,39.67 53.73,42.57 53.73,44.73 48.19,50.28 48.19,58.42 43.97,62.65 43.97,63.87 44.76,64.66 46.86,64.66 47.72,65.53 47.72,69.63 v1(48.07,69.97)
KSO7: length 73
  TOP w0.112: v2(55.6,75.61) 54.99,76.21 54.51,76.21 54.47,76.17 54.01,76.17 53.59,75.75 RE81.2 52.74,75.62 52.16,76.21 UE1.50 49.87,76.21 49.41,76.67 45.38,76.67 v1(44.99,76.28)
  BOTTOM w0.112: v1(44.99,76.28) 44.99,75.59 48.23,72.35 48.23,71.5 47.45,70.72 47.45,65.57 46.75,64.88 44.67,64.88 43.75,63.96 43.75,62.56 47.98,58.33 47.98,50.19 53.52,44.65 53.52,42.48 56.55,39.46 59.5,39.46 61.73,37.23 64.39,37.23 64.64,36.98 66.36,36.98 68.55,34.79 JKB1.12
KSO8: length 72.6
  TOP w0.112: v2(55.83,73.16) 55.83,73.31 55.31,73.82 54.92,73.82 54.77,73.97 53.96,73.97 53.59,74.34 RE86.2 52.8,74.35 52.55,74.61 UE1.46 50.58,74.61 49.56,75.63 v1(45.74,75.63)
  BOTTOM w0.112: JKB1.14 70.15,34.79 69.76,35.18 68.94,35.18 66.71,37.41 64.81,37.41 63.46,38.77 60.8,38.77 59.68,39.89 56.72,39.89 53.95,42.66 53.95,44.82 48.41,50.36 48.41,58.51 44.18,62.73 44.18,63.78 44.85,64.45 46.95,64.45 47.98,65.48 47.98,69.15 48.52,69.69 48.52,72.37 45.74,75.14 v1(45.74,75.63)
KSO9: length 77.5
  TOP w0.112: v1(47.62,81.62) 48.55,82.55 UE1.68 48.55,84.24 49.42,85.11 49.42,85.99 RE18.1 49.41,86.93 49.41,88.03 v2(49.88,88.5)
  BOTTOM w0.112: JKB1.24 78.15,34.74 75.32,37.57 69.56,37.57 66.24,40.9 61.81,40.9 60.69,42.02 57.61,42.02 56.12,43.51 56.12,45.67 52.79,49 52.79,68.27 51.28,69.78 51.28,74.52 46.73,79.07 46.73,79.85 46.29,80.29 46.29,80.61 47.3,81.62 v1(47.62,81.62)
KSO10: length 78.8
  TOP w0.112: RE82.2 48.5,86 48.92,86 49.11,85.8 v2(49.11,85.25) 49.11,85.1 48.5,84.49 47.11,84.49 46.95,84.33 UE1.72 46.95,81.65 v1(47.56,81.03)
  BOTTOM w0.112: JKB1.26 79.75,34.94 76.68,38 69.74,38 66.41,41.33 62.02,41.33 60.9,42.45 57.78,42.45 56.54,43.69 56.54,45.85 53.22,49.17 53.22,68.48 51.79,69.91 51.79,74.67 50.83,75.62 50.83,77.66 50.26,78.23 48.35,78.23 47.16,79.43 47.16,80.84 47.35,81.03 v1(47.56,81.03)
KSO11: length 75.1
  TOP w0.112: RE83.2 47.35,86.51 v2(47.35,85.24) 46.96,84.84 46.63,84.84 46.15,84.37 UE1.74 46.15,80.97 v1(46.68,80.45)
  BOTTOM w0.112: v1(46.68,80.45) 46.94,80.18 46.94,79.15 51.53,74.57 51.53,69.85 53,68.38 53,49.09 56.33,45.76 56.33,43.6 57.69,42.23 60.79,42.23 61.91,41.12 66.32,41.12 69.65,37.79 75.98,37.79 78.95,34.82 JKB1.25
KSO12: length 73.8
  TOP w0.112: v1(44.28,78.32) 44.64,78.67 44.71,78.67 45.75,79.71 UE1.75 45.75,84.49 45.63,84.61 v2(45.63,85.44) 45.63,85.82 RE84.2
  BOTTOM w0.112: JKB1.19 74.15,34.68 74.04,34.79 73.68,34.79 72.19,36.28 69.35,36.28 67.15,38.48 65.26,38.48 63.9,39.84 61.24,39.84 60.12,40.95 57.16,40.95 55.01,43.1 55.01,45.26 49.47,50.81 49.47,63.68 48.23,64.92 48.23,68.32 49.56,69.65 49.56,73.53 44.78,78.32 v1(44.28,78.32)
KSO13: length 76
  TOP w0.112: v1(44.74,79.8) 45.47,80.53 45.47,82.48 45.35,82.6 UE1.76 45.35,84.43 45.1,84.68 44.01,84.68 43.89,84.8 v2(43.89,85.21) 43.89,85.56 44.23,85.9 45.07,85.9 RE85.2
  BOTTOM w0.112: JKB1.22 76.55,34.79 75.87,35.47 73.9,35.47 72.46,36.92 69.61,36.92 67.42,39.12 65.52,39.12 64.16,40.48 61.54,40.48 60.42,41.59 57.43,41.59 55.69,43.33 55.69,45.49 50.8,50.38 50.8,68.04 50.2,68.64 50.2,73.91 45.12,78.99 45.12,79.5 44.87,79.75 44.87,79.8 v1(44.74,79.8)
KSO14: length 76.7
  TOP w0.112: v1(44.74,80.69) 44.77,80.69 45.25,81.16 45.25,82.27 44.95,82.56 UE1.77 44.95,84.22 44.71,84.47 43.92,84.47 43.56,84.83 43.56,86.37 44.15,86.97 v2(44.15,87) 44.52,87 44.81,86.71 RE88.2
  BOTTOM w0.112: v1(44.74,80.69) 45.13,80.31 45.13,79.85 45.37,79.6 45.37,79.56 45.37,79.56 45.37,79.05 50.45,73.97 50.45,68.77 51.01,68.2 51.01,50.47 55.9,45.58 55.9,43.42 57.52,41.81 60.52,41.81 61.64,40.69 66.15,40.69 69.7,37.13 72.54,37.13 73.99,35.69 76.22,35.69 77.35,34.55 JKB1.23
KSO15: length 76.3
  TOP w0.112: v1(40.6,81.91) 40.71,81.91 41.35,82.55 UE1.86 v2(41.35,85.19) 41.35,85.45 41.44,85.53 RE87.2
  BOTTOM w0.112: JKB1.21 75.75,34.83 75.32,35.26 73.81,35.26 72.37,36.71 69.52,36.71 67.33,38.9 65.43,38.9 64.07,40.26 61.45,40.26 60.33,41.38 57.34,41.38 55.48,43.24 55.48,45.41 50.59,50.3 50.59,63.17 48.74,65.02 48.74,68.13 49.99,69.38 49.99,73.81 44.44,79.35 44.28,79.35 44.26,79.33 43.82,79.33 42,81.15 40.74,81.15 40.6,81.29 v1(40.6,81.91)
KSO16: length 78
  TOP w0.102: UE1.92 38.95,84.85
  TOP w0.112: v2(38.62,87.97) 38.62,87.55 38.27,87.21 38.27,86.71 38.73,86.25 RE89.2 38.77,85.03 38.95,84.85 ; v1(40.29,80.94) 38.95,82.28 UE1.92
  BOTTOM w0.112: JKB1.20 74.95,34.37 74.27,35.05 73.73,35.05 72.28,36.49 69.44,36.49 67.24,38.69 65.34,38.69 63.99,40.05 61.36,40.05 60.24,41.17 57.25,41.17 55.23,43.19 55.23,45.35 49.69,50.89 49.69,63.76 48.48,64.97 48.48,68.19 49.77,69.48 49.77,73.7 44.35,79.12 43.73,79.12 41.91,80.94 v1(40.29,80.94)
LAN_MDIN0: length 12.3
  TOP w0.089: UL1.2 23.2,79.75 23,79.55 23,76.67 v4(23.24,76.42) 24.9,74.76 26.42,74.76 27.34,73.85 27.34,72.41 27.1,72.17 27.04,72.17 26.72,71.86 TL1.15
LAN_MDIN1: length 21.2
  TOP w0.089: UL1.5 24.4,76.82 25.36,75.86 26.88,75.86 v4(27.8,74.94) 28.48,74.26 28.48,71.18 29.21,70.45 29.21,67.33 28.9,67.02 28.9,65.84 27.64,64.57 27.13,64.57 27.01,64.46 27.01,64.37 26.88,64.24 TL1.9
LAN_MDIN2: length 10.7
  TOP w0.089: UL1.7 25.2,79.79 25.16,79.76 25.16,78.65 v4(25.4,78.41) 26.07,77.74 26.07,77.31 v1(26.16,77.22)
  BOTTOM w0.089: TL2.10 26.49,71.86 26.89,72.25 27.23,72.25 27.46,72.49 27.46,74.23 26.07,75.63 26.07,77.13 v1(26.16,77.22)
LAN_MDIN3: length 20.9
  TOP w0.089: UL1.10 26.72,81.26 27.28,80.7 v4(27.28,79.95) 27.28,79.62 27.21,79.56 27.21,77.91 v1(27.34,77.78)
  BOTTOM w0.089: TL2.16 26.63,64.24 26.79,64.4 27.31,64.4 29.41,66.5 29.41,71.49 28.57,72.34 28.57,74.69 27.34,75.91 v1(27.34,77.78)
LAN_MDIP0: length 12.3
  TOP w0.089: TL1.16 26.77,73.13 26.86,73.04 26.86,72.5 26.93,72.42 27,72.42 27.09,72.51 27.09,73.74 26.32,74.51 24.8,74.51 22.74,76.56 v4(22.74,78.43) 22.74,79.65 22.8,79.71 UL1.1
LAN_MDIP1: length 21.2
  TOP w0.089: TL1.10 26.84,65.51 26.97,65.37 26.97,64.89 27.03,64.83 27.54,64.83 28.65,65.94 28.65,67.13 28.96,67.43 28.96,70.35 28.23,71.07 28.23,74.16 26.78,75.61 25.25,75.61 24.15,76.72 v4(24.15,77.67) 24.15,79.66 24,79.8 UL1.4
LAN_MDIP2: length 10.7
  TOP w0.089: v1(25.58,77.22) 25.6,77.22 25.82,77.44 25.82,77.64 24.91,78.55 24.91,79.73 24.8,79.84 UL1.6
  BOTTOM w0.089: TL2.9 26.66,73.13 26.91,72.88 26.91,72.59 27,72.5 27.12,72.5 27.21,72.59 27.21,74.13 25.82,75.52 25.82,76.98 v1(25.58,77.22)
LAN_MDIP3: length 20.9
  TOP w0.089: UL1.9 26.76,80.86 27.02,80.6 27.02,79.62 26.96,79.56 26.96,77.99 v1(26.75,77.78)
  BOTTOM w0.089: v1(26.75,77.78) 27.09,77.45 27.09,75.81 28.31,74.58 28.31,72.24 29.16,71.39 29.16,66.6 27.21,64.65 26.92,64.65 26.83,64.74 26.83,65.42 26.74,65.51 TL2.15
LANWAKE#: length 103.6
  TOP w0.112: v1(54.19,64.94) 54.39,65.15 v2(54.39,65.48) 54.39,68.13 54.26,68.26 53.56,68.26 52.41,69.41 52.41,69.93 52.14,70.21 UE1.35
  IN2 w0.124: v1(116.32,58.19) 115,58.19 108.87,52.07 106.9,52.07 104.08,49.24 103.89,49.24 103.43,48.77 101.46,48.77 100.63,47.95 89.67,47.95 85.78,44.06 81.36,44.06 80.68,43.38 79.51,43.38 77.93,41.8 76.41,41.8 75.91,42.31 75.91,42.58 75.41,43.08 74.69,43.08 73.42,41.8 70.66,41.8 69.89,42.58 63.73,42.58 63.01,43.3 61.74,43.3 61.19,43.86 58.09,43.86 57.57,44.37 57.57,46.78 54.88,49.48 54.88,64.25 v1(54.19,64.94)
  BOTTOM w0.076: v1(116.32,58.19) 116.2,58.19 115.86,57.84 115.86,57.53 115.52,57.18 115.52,56.97 115.29,56.74 113.87,56.74 113.45,56.32 RC93.2
  BOTTOM w0.102: v1(116.32,58.19) 116.59,58.46 UC1.BU32
LANXIN: length 2.4
  TOP w0.112: RL2.2 20.49,82.29 20.65,82.13 21.12,82.13 21.45,82.46 UL1.28
LANXIN_R: length 4.8
  TOP w0.112: YL1.1 17.15,81.87 18.62,81.87 RL2.1 19.89,83.14 CL1.1
LANXOUT: length 2.4
  TOP w0.112: UL1.29 21.43,82.06 21.23,81.86 20.37,81.86 RL3.2
LANXOUT_R: length 2.9
  TOP w0.112: RL3.1 20,80.63 CL7.1 18.89,81.25 18.41,81.25 YL1.3
LCD_BRIGHTNESS: length 5.9
  TOP w0.112: v2(217.55,47.49) 217.23,47.49 216.8,47.93 R79.1 215.98,47.93 215.43,47.37 214.7,47.37 214.27,47.79 v1(213.99,47.79)
  BOTTOM w0.112: v1(213.99,47.79) 213.92,47.79 213.57,47.45 JEDP1.27
LCD_CBL_DET#: length 128.5
  TOP w0.112: v1(211.4,54.73) 211.21,54.73 210.32,55.61 210.32,55.63 R90.2 ; v2(173.34,39.4) 173.74,39.81 v1(173.9,39.81)
  IN1 w0.089: 128.43,49.59 128.65,49.59 v1(128.75,49.49)
  IN1 w0.119: 128.43,49.59 127.9,49.59 126.76,48.45 126.65,48.45 126.4,48.19 126.4,48.08 126.03,47.72 126.03,47.23 126.4,46.86 126.4,45.65 124.49,43.75 123.99,43.75 123.85,43.61 123.85,42.51 124.66,41.7 v1(124.71,41.7)
  IN2 w0.124: v1(124.71,41.7) 126.13,41.7 126.78,42.35 127.42,42.35 127.54,42.22 128.61,42.22 128.75,42.36 128.75,43.49 129.26,44 131.1,44 131.85,44.75 132.91,44.75 133.4,45.24 134.89,45.24 136.08,44.05 140.26,44.05 144.75,39.56 147.23,39.56 147.65,39.13 152.73,39.13 153.59,38.27 158.56,38.27 160.37,40.08 166.32,40.08 167.12,39.29 173.37,39.29 v1(173.9,39.81)
  IN3 w0.135: v1(211.4,54.73) 211.25,54.73 210.6,54.07 210.6,53.4 212.63,51.37 212.63,46.25 212.46,46.08 212.46,45.48 212.4,45.42 212.4,42.63 211.17,41.4 209.27,41.4 208.69,41.97 206.16,41.97 205.64,41.46 198.92,41.46 198.15,40.7 198.15,39.73 197.45,39.02 196.94,39.02 194.58,36.66 190.76,36.66 190.32,37.11 179.14,37.11 177.45,38.79 174.28,38.79 173.9,39.17 v1(173.9,39.81)
  BOTTOM w0.076: UC1.CN14 128.38,49.29 128.56,49.46 128.69,49.46 128.72,49.49 v1(128.75,49.49)
  BOTTOM w0.112: v1(211.4,54.73) 211.62,54.51 211.62,54.16 211.83,53.95 JEDP1.14
LCD_TST: length 265.5
  TOP w0.112: D2.3 219.91,54.1 R80.2 v2(221.64,52.88) 221.64,52.37 v1(221.21,51.95) ; UE1.26 47.35,68.62 46.17,69.8 v1(45.92,69.8)
  IN1 w0.119: v1(33.77,68.6) 36.29,71.12 36.29,73.19 36.96,73.85 43.16,73.85 45.92,71.09 v1(45.92,69.8)
  IN2 w0.124: v1(33.77,68.6) 33.35,68.18 33.35,67.07 36.85,63.56 38.47,63.56 39.08,62.95 39.77,62.95 41.41,61.31 42.29,61.31 45.38,58.22 45.38,54.63 44.45,53.7 44.45,39.17 50.21,33.4 54.5,33.4 59.71,28.19 60.18,28.19 61.34,27.03 65.92,27.03 66.53,27.64 67.78,27.64 68.68,26.74 99.7,26.74 101.69,28.73 115.61,28.73 116.88,29.99 131.91,29.99 135.01,33.1 145.09,33.1 146.08,32.11 150.27,32.11 151.54,30.85 151.54,29.39 152.24,28.69 158.07,28.69 159.18,29.79 162.07,29.79 162.59,29.27 165.26,29.27 166.66,30.67 172.12,30.67 173.2,29.58 175.65,29.58 179.7,33.63 188.61,33.63 189.17,34.19 197.65,34.19 198.53,35.07 206.88,35.07 208.23,36.43 211.73,36.43 214.25,38.95 214.25,40.22 214.96,40.93 217.71,40.93 218.97,42.18 218.97,42.37 218.97,42.37 218.97,49.7 v1(221.21,51.95)
LCD_TST_C: length 12
  TOP w0.112: v1(221.27,54.92) 221.45,55.1 v2(222.45,55.1) 222.55,55 R80.1
  IN1 w0.119: v1(214.66,55.55) 215.18,56.07 216.57,56.07 217.28,55.36 220.83,55.36 v1(221.27,54.92)
  BOTTOM w0.112: v1(214.66,55.55) 214.27,55.94 212.38,55.94 JEDP1.10
LCD_VCC_TEST_EN: length 250.6
  TOP w0.112: UE1.113 37.59,75.41 v1(37.69,75.31) ; v2(216.35,59.95) 216.51,59.95 216.93,59.53 v1(216.95,59.53) 217.35,59.93 D4.3
  IN2 w0.124: v1(37.69,75.31) 37.69,75.24 37.95,74.98 37.95,73.59 39.34,72.19 39.34,69.4 37.09,67.15 37.09,65.02 37.42,64.69 38.94,64.69 39.55,64.08 40.32,64.08 41.96,62.44 42.76,62.44 46.51,58.69 46.51,55.69 47.97,54.23 47.97,49.21 46.17,47.42 46.17,39.36 50.78,34.76 55.06,34.76 60.2,29.62 60.66,29.62 61.9,28.38 65.35,28.38 65.97,29 68.34,29 68.51,28.82 70.89,28.82 71.57,29.5 94.25,29.5 96.71,31.97 103.72,31.97 104.69,32.94 120.16,32.94 120.3,33.08 121.97,33.08 122.99,32.07 123.82,32.07 124.98,33.22 127.89,33.22 128.59,32.53 128.59,32.53 129.28,31.84 131.2,31.84 134.26,34.91 145.87,34.91 146.86,33.92 158.23,33.92 158.96,34.65 171.84,34.65 173.26,36.07 195.94,36.07 197.43,37.56 205.17,37.56 207.28,39.66 208.39,39.66 209.59,40.86 210.45,40.86 212.77,43.19 215.76,43.19 216.7,44.13 216.7,45.33 v1(216.62,45.4)
  IN3 w0.135: v1(216.62,45.4) 216.62,45.67 216.76,45.8 216.91,45.8 218.7,47.59 218.7,55.08 218.32,55.46 218.32,57.87 216.95,59.24 v1(216.95,59.53)
LCDVDD_EN: length 9.4
  TOP w0.112: R17.1 220.06,56.13 U1.4 219.68,56.13 219.3,56.51 219.3,60.45 219.74,60.89 D4.1 221.43,60.89 v2(222.2,60.13)
LDO1_CAP: length 3.8
  TOP w0.203: UA1.21 28.76,14.81 28.58,14.99 28.58,15.35 28.13,15.81 v2(28,15.81) CA19.2 26.98,16.77 RA13.2
LDO2_CAP: length 2.1
  TOP w0.203: UA1.32 30.26,10.03 29.18,8.95 CA21.2
LDO3_CAP: length 3.4
  TOP w0.203: UA1.6 34.63,13.21 34.7,13.14 CA22.2
LED1: length 8.1
  TOP w0.112: v1(17.75,79.56) 17.28,79.56 RL16.1 ; UL1.26 20.82,83.26 v1(20.6,83.04)
  BOTTOM w0.112: v1(20.6,83.04) 19.77,82.22 RL6.2 19.68,79.53 v2(18.48,79.53) 17.78,79.53 v1(17.75,79.56)
LG1_CHG: length 8
  TOP w0.112: v1(195.06,39.94) v2(195.61,39.94)
  IN3 w0.762: 195.74,39.81 196.88,39.81 197.27,40.19 197.27,41.08 198.73,42.54 201.52,42.54
  vias: v1(194.47,39.94) v1(201.96,43.18) v1(202.41,43.62)
LG1_VGA: length 6.1
  IN3 w0.762: 78.6,128.94 80.81,128.94 81.58,128.17 83.52,128.17
  BOTTOM w0.112: v1(89.66,128.37) 90.15,128.37 v2(90.43,128.65)
  vias: v1(77.88,128.86) v1(84.48,128.52) v1(84.48,127.94) v1(89.66,127.78)
LG2_VGA: length 6
  TOP w0.112: v1(77.91,129.99) 77.93,129.99
  IN3 w0.762: 83.4,131.84 81.59,130.03 78.95,130.03
  BOTTOM w0.112: v1(84.57,131.5) 84.13,131.07 v2(84.13,130.87)
  vias: v1(84.57,132.09) v1(89.72,132.02) v1(89.72,131.44)
LG_1.2V: length 3.7
  IN3 w0.635: v1(40.5,24.99) 43.55,24.99 v1(44.01,24.53)
  vias: v2(39.53,25.71)
LG_VCCSA: length 6.5
  TOP w0.112: v1(161.07,51.75) v2(161.07,52.28)
  IN1 w0.508: v1(161.07,51.75) 162.01,52.69 165.22,52.69 v1(166.24,51.67)
LID_CL_SIO#: length 273
  TOP w0.112: R25.1 v1(220.58,63.43) ; D3.1 213.64,40.75 218.3,40.75 218.63,41.08 219.71,41.08 220.91,42.27 v1(222.87,42.27) ; UE1.66 49.35,84.3 49.83,84.78 51.32,84.78 v3(51.54,84.99) 51.74,85.2 CE16.1 52.52,86.26 RE28.2 52.58,85.62 v1(52.3,85.34)
  IN1 w0.119: v1(184.02,62.82) 184.41,63.21 204.09,63.21 206.28,61.02 212.11,61.02 213.41,62.32 217.9,62.32 219.01,63.43 v1(220.58,63.43) 220.58,62.15 224.19,58.54 224.19,43.59 v1(222.87,42.27)
  IN2 w0.124: v1(184.02,62.82) 184.02,64.61 181.24,67.38 181.24,70.74 180.42,71.56 172.87,71.56 168.3,76.13 168.3,88.26 167.79,88.77 167.79,94.48 157.2,105.07 144.17,105.07 143.54,104.44 139.04,104.44 134.89,108.59 131.05,108.59 130,107.55 126.54,107.55 122.69,111.4 114.05,111.4 113.62,110.97 87.18,110.97 85.17,112.99 57.09,112.99 51.98,107.88 51.98,93.78 52.87,92.9 52.87,85.91 v1(52.3,85.34)
LID_CLOSE#: length 3.6
  TOP w0.112: v2(223.35,61.78) v1(223.35,62.29) EC2.1 R25.2
  BOTTOM w0.112: JPWR1.3 223.24,62.4 v1(223.35,62.29)
LIMT_+1.35VGPU: length 4.6
  TOP w0.112: v2(146.74,112.14) 146.48,111.87 PRW03.2
  TOP w0.254: PRW03.2 145.92,111.15 v1(145.72,110.94)
  BOTTOM w0.254: PUW01.12 144.25,110.24 144.37,110.36 144.62,110.36 144.94,110.68 144.94,111.25 PRW04.1 145.21,111.45 v1(145.72,110.94)
LINE1-L_C: length 8.8
  TOP w0.127: v1(23.96,15.55) 24.55,15.55 v2(24.84,15.85)
  TOP w0.254: RA28.1 v1(23.96,15.55) ; 29.18,19.11 v1(29.18,18.41)
  IN3 w0.254: v1(29.18,18.41) 27.66,16.89 25.29,16.89 v1(23.96,15.55)
LINE1-L_R: length 10.5
  TOP w0.254: RA31.1 v1(23.34,13.2) ; 30.39,19.11 v1(30.39,18.41)
  IN3 w0.254: v1(23.34,13.2) 26.45,16.31 28.29,16.31 v1(30.39,18.41)
LINE1_L: length 3.2
  TOP w0.203: UA1.18 30.66,15.92 30.59,15.99 30.59,16.59 30.23,16.95 29.45,16.95 29.18,17.22 CA33.1
LINE1_R: length 2.4
  TOP w0.203: UA1.17 31.06,15.96 30.97,16.05 v2(30.97,16.67) 30.97,16.77 30.39,17.36 CA34.1
LOM_CABLE_DETECT: length 47.3
  TOP w0.112: v1(48.93,72.61) UE1.41 ; RL16.2 v1(16.02,79.43)
  IN1 w0.119: v1(29.83,71.99) 30.13,71.69 31.66,71.69 31.91,71.93 31.91,73.34 32.65,74.08 42.43,74.08 42.93,74.58 v1(44.55,74.58)
  IN3 w0.135: v1(29.83,71.99) 29.83,72.88 29.37,73.34 29.37,74.76 29.24,74.9 23.8,74.9 19.53,79.16 16.29,79.16 v1(16.02,79.43)
  BOTTOM w0.112: v1(48.93,72.61) 48.93,73.21 45.25,76.89 44.61,76.89 44.1,76.39 44.1,75.03 v1(44.55,74.58)
LOM_TCT: length 14.2
  TOP w0.508: TL1.14 26.78,70.59 27.59,69.78 v1(27.59,69.4) 27.9,69.1 v2(27.9,68.28) 27.9,67.93 26.75,66.78 TL1.11
  BOTTOM w0.508: TL1.14 26.67,70.59 26.84,70.42 27.96,70.42 CL21.1 28.1,69.91 v1(27.59,69.4) 27.59,67.56 26.81,66.78 TL1.11
LX1_CHG: length 12.5
  TOP w0.112: PRB40.1 v2(188.51,43.81)
  IN3 w0.762: 190.47,44.83 191.2,44.83 192.53,43.49 200.57,43.49
  vias: v1(189.14,44.89) v1(189.72,44.89) v1(190.03,42.92) v1(190.61,42.92) v1(201.33,43.68) v1(201.71,44.13)
LX1_VGA: length 11.3
  IN3 w0.762: 78.61,128.01 80.22,126.4 83.86,126.4 84.89,125.37 88.77,125.37
  vias: v1(77.88,128.2) v1(89.44,126.55) v1(89.45,127.16) v1(89.45,125.81) v1(89.45,125.2) v1(90.06,127.16) v1(90.08,126.55) v1(90.23,124.34) v1(90.65,127.19) v1(90.71,126.42) v1(90.81,124.34) v1(91.4,124.34) v1(91.98,124.34) v1(92.19,124.95) v1(92.57,124.34) v1(92.95,124.95) v1(93.34,125.41) v1(94.74,126.45) v1(94.94,127.02) v1(95.22,128.58) v1(95.22,127.95) v1(95.4,126.5) v1(95.53,127.07) v1(95.79,128.39) v1(95.79,127.8) v1(95.77,125.97) v1(96.12,127.16) v1(96.12,126.55) v1(96.38,127.8) v1(96.35,125.97) v1(96.71,127.16) v1(96.71,126.55) v1(96.94,125.97) v3(93.61,126.22)
LX2_VGA: length 13.1
  IN3 w0.762: 78.71,130.93 80.5,132.71 80.93,132.71 82.82,134.6 89.87,134.6 90.15,134.88
  vias: v1(77.84,130.58) v1(89.53,133.45) v1(89.81,132.84) v1(90.14,133.45) v1(90.42,132.84) v1(90.5,136.01) v1(90.65,135.43) v1(90.75,133.45) v1(91.03,132.84) v1(91.11,136.01) v1(91.35,136.58) v1(91.26,135.43) v1(91.64,132.84) v1(91.72,136.01) v1(91.87,135.43) v1(91.98,136.58) v1(92.32,136.01) v1(92.62,136.58) v1(93.01,136.08) v1(93.44,136.51) v1(93.44,135.65) v1(93.87,136.08) v1(93.87,135.22) v1(94.31,135.65) v3(93.25,133.79)
LX_1.2V: length 7
  IN3 w0.635: v1(40.36,26.54) 40.48,26.41 46.6,26.41 v1(47.09,25.93)
  vias: v1(47.07,28.89) v2(47,29.73)
LX_1.05V: length 0.7
  TOP w0.112: v1(156.63,47.68) v2(156.63,48.37)
  vias: v1(157.26,47.68)
LX_1.8V: length 1.5
  TOP w0.112: v2(200.02,52.13) 199.36,52.79 v1(199.36,53.4)
  vias: v1(199.36,54.03)
LX_3V: length 2.2
  TOP w0.112: v1(26.62,42.23) v2(26.62,41.63)
  TOP w0.508: PR305.1 v1(26.62,42.23)
LX_5V: length 4.8
  TOP w0.112: v2(22.49,98.64) 22.49,99.13 v1(22.13,99.48)
  TOP w0.508: PR505.1 v1(22.13,99.48)
  BOTTOM w0.508: PC507.2 23.19,103.46 22.36,102.64 22.36,101.82
LX_+1.35VGPU: length 2.1
  TOP w0.112: v1(148.85,110.11) 148.85,111.02 v2(148.51,111.36)
  TOP w0.508: PCW12.2 v1(148.73,108.23)
  vias: v1(148.85,109.48)
LX_VCCSA: length 2.8
  TOP w0.112: PRA02.1 v2(159.42,52.13)
  TOP w0.508: PCA07.2 166.52,52.94 v1(166.16,53.3)
  vias: v1(160.34,54.4) v1(160.34,53.76)
LX_VCORE1: length 2.7
  TOP w0.508: PRI03.1 156.9,62.2 v2(157.59,62.9) 157.81,63.11 v1(158.28,63.11)
LX_VCORE2:
  vias: v1(155.45,88.56) v1(155.45,87.74) v2(155.93,88.04)
LX_VGT1: length 1
  TOP w0.112: v1(150.53,91.37) v2(150.53,90.34)
  vias: v1(150.53,92.01)
M2_SSD_PEDET: length 134.7
  TOP w0.112: v1(38.77,39.17) 39.11,39.52 48.19,39.52 49.03,40.36 v2(50.82,40.36) 51.54,40.36 52.17,39.73 v1(52.17,39.49)
  IN2 w0.124: v1(52.17,39.49) 52.17,39.3 53.04,38.43 57.72,38.43 60.88,35.27 67.84,35.27 68.16,34.96 80.4,34.96 82.71,37.27 83.6,37.27 84.12,36.75 93.97,36.75 95.33,35.38 117.25,35.38 119.1,37.24 120.72,37.24 121.12,36.83 130.21,36.83 132.32,38.94 132.32,41.27 132.96,41.91 v1(133.19,41.91)
  IN3 w0.135: v1(38.77,39.17) 38.77,41.02 37.48,42.31 34.98,42.31 33.99,41.31 31.81,41.31 30.62,40.12 28.06,40.12 26.29,38.35 v1(25.12,38.35)
  BOTTOM w0.102: UC1.CP10 131.19,48.38 131.19,47.84 131.04,47.68 131.02,47.68 131.02,47.45 131.24,47.24 131.24,46.52 132.17,45.58 132.17,45.24 132.33,45.08 132.33,44.59 132.65,44.27 132.65,43.45 132.55,43.35 132.55,42.5
  BOTTOM w0.112: v1(25.12,38.35) 25.12,37.77 RS1.2 22.38,35.02 JSSD1.69 ; v1(133.19,41.91) 132.9,41.91 132.55,42.25 132.55,42.5
M_ABIA0: length 42.4
  TOP w0.127: 136.58,134 135.64,134 135.53,133.89 134.56,133.89 133.99,134.45 132.1,134.45 131.67,134.02 129.49,134.02 v1(128.91,134.6)
  TOP w0.14: v1(155.51,138.33) 155.85,137.99 155.85,137.12 155.95,137.02 158.16,137.02 158.3,136.88 158.3,136.41 158.13,136.24 155.18,136.24 155.04,136.1 155.04,135.62 154.15,134.74 153.55,134.74 153.34,134.53 153.34,133.97 153.15,133.79 152.94,133.79 152.8,133.93 152.8,134.6 152.66,134.74 152.38,134.74 152.24,134.6 152.24,133.93 152.1,133.79 151.82,133.79 151.68,133.93 151.68,134.6 151.54,134.74 151.26,134.74 151.12,134.6 151.12,133.93 150.98,133.79 150.7,133.79 150.56,133.93 150.56,134.6 150.42,134.74 150.15,134.74 150.01,134.6 150.01,133.93 149.87,133.79 v2(142.55,133.79) 139.87,133.79 139.67,133.99 136.59,133.99 136.58,134
  BOTTOM w0.102: v1(128.91,134.6) 128.71,134.8 UV1.L18
  BOTTOM w0.127: v1(155.51,138.33) 155.11,138.73 UV13.J4
M_ABIA1: length 43.6
  TOP w0.127: 134.87,130.95 134.07,130.95 133.88,131.13 133.81,131.13 132.67,132.27 132.27,132.27 131.97,131.97 131.42,131.97 130.71,132.68 129.91,132.68 129.22,133.37 v1(129.22,133.43)
  TOP w0.14: 134.87,130.95 135.3,130.51 v2(146.08,130.51) 147.7,130.51 147.84,130.37 147.84,130.1 147.7,129.96 144.38,129.96 144.24,129.82 144.24,129.54 144.38,129.4 147.7,129.4 147.88,129.22 147.88,125.6 148.28,125.2 152.27,125.2 v1(152.82,125.75)
  BOTTOM w0.112: v1(152.82,125.75) 152.82,125.34 153.21,124.95 153.79,124.95 154.15,124.6 154.15,124.3 155.49,122.95 155.49,122.09 UV15.J4
  BOTTOM w0.127: v1(129.22,133.43) 128.94,133.15 UV1.K16
