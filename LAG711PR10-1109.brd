# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA13: length 54.7
  IN1 w0.089: 104.02,77.07 104.47,77.07 104.97,77.57 110.91,77.57 110.91,77.57 111.94,77.57 112.27,77.24 113.44,77.24 115.2,79.01 115.2,79.28 115.8,79.88 116.66,79.88 116.67,79.87 v1(116.67,79.88)
  IN1 w0.147: v1(73.51,69.06) 73.02,68.58 72.42,68.58 72.23,68.77 72.23,69.4 72.51,69.68 82.31,69.68 82.89,70.26 85.7,70.26 92.02,76.58 103.53,76.58 104.02,77.07
  BOTTOM w0.102: v1(116.67,79.88) 116.67,79.87 116.72,79.82 UC1.AC32
  BOTTOM w0.14: v1(73.51,69.06) 73.07,68.62 72.19,68.62 72.07,68.74 70.96,68.74 JDIMM1.158
DDR_A_ODT0: length 57.9
  IN1 w0.089: 103.51,75.1 104.93,76.51 106.42,76.51 106.65,76.28 112.67,76.28 112.93,76.02 113.64,76.02 114.11,76.5 114.11,77.01 114.25,77.14 114.38,77.14 114.55,76.98 114.67,76.98 114.8,77.1 114.8,77.23 114.63,77.4 114.63,77.52 115.21,78.1 116.09,78.1 116.42,78.43 116.8,78.43 v1(117.33,78.96)
  IN1 w0.147: 103.51,75.1 92.63,75.1 89.76,72.22 89.76,71.62 85.73,67.59 81.95,67.59 81.63,67.91 76.24,67.91 75.79,68.37 75.58,68.37 75.15,67.94 73.81,67.94 73.67,68.09 73.67,68.3 74.03,68.66 74.88,68.66 75.03,68.81 v1(75.03,69.06)
  BOTTOM w0.089: v1(117.33,78.96) 117.34,78.96 117.34,78.95 117.35,78.94 117.54,78.54 UC1.AE31
  BOTTOM w0.14: v1(75.03,69.06) 75.56,68.54 77.36,68.54 78.31,69.49 JDIMM1.155
DDR_A_ODT1: length 58.2
  IN1 w0.147: v1(76.56,66.89) 76.37,66.89 75.98,66.5 75.98,66.16 76.14,66 76.96,66 77.26,66.3 77.85,66.3 77.99,66.45 77.99,66.93 78.14,67.08 78.43,67.08 78.58,66.93 78.58,66.45 78.73,66.3 79.02,66.3 79.17,66.45 79.17,66.93 79.32,67.08 79.61,67.08 79.76,66.93 79.76,66.45 79.91,66.3 82.2,66.3 82.67,66.76 86.07,66.76 90.59,71.28 90.59,71.88 92.98,74.27 103.43,74.27 104.47,75.31 105.06,75.31 105.21,75.16 105.21,74.88 105.36,74.73 105.65,74.73 105.8,74.88 105.8,75.67 105.95,75.81 106.24,75.81 106.39,75.67 106.39,74.88 106.53,74.73 106.83,74.73 106.98,74.88 106.98,75.01 107.12,75.16 107.42,75.16 107.57,75.01 107.57,74.88 107.71,74.73 108.01,74.73 108.16,74.88 108.16,75.01 108.3,75.16 108.6,75.16 108.74,75.01 108.74,74.88 108.89,74.73 109.19,74.73 109.33,74.88 109.33,75.01 109.48,75.16 111.94,75.16 112.24,74.85 114.2,74.85 115.16,75.81 115.16,76.85 115.57,77.26 116.53,77.26 v1(117.31,78.04)
  BOTTOM w0.089: 117.37,77.98 v1(117.31,78.04)
  BOTTOM w0.127: 117.37,77.98 117.56,77.78 UC1.AF31
  BOTTOM w0.14: v1(76.56,66.89) 77.27,67.6 77.89,67.6 78.27,67.99 JDIMM1.161
DDR_A_PAR: length 49.9
  IN1 w0.089: 104.03,78.65 104.2,78.48 110.65,78.48 111.3,79.14 112.33,79.14 112.98,79.79 114.26,79.79 116.04,81.57 116.04,81.91 116.45,82.32 116.9,82.32 117.26,82.68 v1(117.26,82.69)
  IN1 w0.147: 104.03,78.65 91.16,78.65 84.84,72.33 76.53,72.33 v1(76.49,72.3)
  BOTTOM w0.102: v1(117.26,82.69) 117.29,82.69 UC1.W31
  BOTTOM w0.14: JDIMM1.143 78.15,74.49 77.89,74.23 77.89,73.69 v1(76.49,72.3)
DDR_A_RAS#: length 51.1
  IN1 w0.089: 103.77,77.82 103.95,78 103.99,78 104.09,78.1 111.71,78.1 112.09,78.48 113.47,78.48 116.69,81.69 v1(116.69,81.73)
  IN1 w0.147: v1(72.79,70.71) 73.25,71.18 76.67,71.18 76.99,71.5 85.18,71.5 91.5,77.82 103.77,77.82
  BOTTOM w0.102: v1(116.69,81.73) 116.7,81.72 116.7,81.69 UC1.Y32
  BOTTOM w0.14: JDIMM1.152 72.31,70.24 v1(72.79,70.71)
DDR_A_WE#: length 54.7
  IN1 w0.089: v1(117.31,79.88) 117.31,79.87 117.53,79.87 117.62,79.78 117.62,79.52 117.53,79.43 116.24,79.43 116.11,79.31 116.11,78.8 115.86,78.54 115.05,78.54 113.51,77.01 112.25,77.01 111.87,77.39 110.57,77.39 109.83,76.66 106.83,76.66 106.6,76.89 106.36,76.89 106.27,76.98 106.27,77.3 106.18,77.39 106.01,77.39 105.92,77.3 105.92,76.98 105.83,76.89 105.65,76.89 105.56,76.98 105.56,77.3 105.47,77.39 105.3,77.39 105.21,77.3 105.21,76.98 105.12,76.89 104.24,76.89 103.51,76.17
  IN1 w0.147: 103.51,76.17 92.19,76.17 85.46,69.43 85.25,69.43 84.83,69.85 84.63,69.85 84.42,69.64 84.42,69.43 84.83,69.02 84.83,68.81 84.68,68.66 83.89,68.66 83.74,68.81 83.74,69.7 83.59,69.85 83.3,69.85 83.15,69.7 83.15,68.81 83,68.66 82.39,68.66 v1(81.98,69.06)
  BOTTOM w0.089: v1(117.31,79.88) 117.31,79.87 117.34,79.86 UC1.AC31
  BOTTOM w0.14: JDIMM1.151 80.84,70.49 80.98,70.35 80.98,69.6 81.12,69.46 81.4,69.46 81.54,69.6 81.54,70.35 81.68,70.49 82.89,70.49 83.03,70.35 83.03,70.11 v1(81.98,69.06)
DDR_B_ACT#: length 66.8
  IN3 w0.089: 105.57,87.56 107.49,85.65 111.32,85.65 112.42,84.55 115.66,84.55 116.52,84.1 117.24,83.91 117.95,83.91 118.15,83.83 v1(119.22,82.64)
  IN3 w0.142: v1(60.83,84.09) 61.67,84.93 65.78,84.93 66.93,86.08 86.66,86.08 88.87,88.29 103.74,88.29 104.29,87.73 105.4,87.73 105.57,87.56
  BOTTOM w0.102: v1(119.22,82.64) UC1.W28
  BOTTOM w0.14: JDIMM2.114 59.01,81.74 60.83,83.56 v1(60.83,84.09)
DDR_B_ALERT#: length 68.4
  IN3 w0.089: 107.86,83.81 108.5,83.63 110.26,83.46 110.38,83.46 111.64,82.2 116.14,82.2 116.21,82.13 117.95,82.13 118.13,82.06 v1(118.6,81.7)
  IN3 w0.142: v1(60.81,82.23) 60.81,82.7 60.54,82.97 59.87,82.97 59.6,83.24 59.6,83.53 59.74,83.67 61.31,83.67 61.8,83.18 65.76,83.18 66.29,83.7 86.02,83.7 89.09,86.78 103.51,86.78 105.9,84.39 107.28,84.39 107.86,83.81
  BOTTOM w0.102: UC1.Y29 v1(118.6,81.7)
  BOTTOM w0.14: JDIMM2.116 59.34,81.24 59.6,81.5 60.07,81.5 v1(60.81,82.23)
DDR_B_BA0: length 67.9
  IN3 w0.089: 101.45,77.34 106.97,77.34 v1(107.22,77.09)
  IN3 w0.142: 101.45,77.34 100.66,78.13 93.27,78.13 89.06,73.92 83.25,73.92 82.51,73.18 70.47,73.18 70.38,73.09 66.27,73.09 66.18,73.17 63.81,73.17 62.88,74.1 59.53,74.1 59.34,73.91 59.34,73.54 59.49,73.4 62.39,73.4 62.67,73.12 62.67,72.74 v1(62.27,72.34)
  BOTTOM w0.076: v1(107.22,77.09) 107.98,76.34 112.62,76.34 113.05,75.9 113.83,75.9 UC1.AJ37
  BOTTOM w0.14: JDIMM2.150 59.16,70.74 60.11,71.69 62.13,71.69 62.27,71.83 v1(62.27,72.34)
DDR_B_BA1: length 68.5
  IN3 w0.089: 101.16,77.05 101.48,76.73 101.79,76.73 101.88,76.82 101.88,77.07 101.97,77.16 102.15,77.16 102.24,77.07 102.24,76.82 102.33,76.73 102.51,76.73 102.59,76.82 102.59,77.07 102.68,77.16 102.86,77.16 102.95,77.07 102.95,76.82 103.04,76.73 103.22,76.73 103.31,76.82 103.31,77.07 103.39,77.16 103.57,77.16 103.66,77.07 103.66,76.82 103.75,76.73 103.94,76.73 104.03,76.82 104.03,77.07 104.12,77.16 104.3,77.16 104.38,77.07 104.38,76.82 104.47,76.73 104.65,76.73 104.74,76.82 104.74,77.07 104.83,77.16 106.77,77.16 106.86,77.07 106.86,76.82 106.95,76.73 107.49,76.73 v1(107.85,77.09)
  IN3 w0.142: v1(63.79,72.34) 64.22,72.76 64.95,72.76 65.1,72.62 65.1,72.5 65.24,72.36 65.52,72.36 65.67,72.5 65.67,72.62 65.81,72.76 66.02,72.76 66.1,72.68 66.28,72.68 66.42,72.54 66.42,72.42 66.56,72.28 66.84,72.28 66.99,72.42 66.99,72.54 67.13,72.68 67.41,72.68 67.56,72.54 67.56,72.42 67.7,72.28 67.98,72.28 68.12,72.42 68.12,72.54 68.27,72.68 68.55,72.68 68.69,72.54 68.69,72.42 68.84,72.28 69.12,72.28 69.26,72.42 69.26,72.54 69.4,72.68 69.69,72.68 69.83,72.54 69.83,72.42 69.97,72.28 70.26,72.28 70.4,72.42 70.4,72.54 70.54,72.68 70.83,72.68 70.97,72.54 70.97,72.42 71.11,72.28 71.4,72.28 71.54,72.42 71.54,72.63 71.68,72.77 76.91,72.77 77.06,72.63 77.06,72.42 77.2,72.28 77.48,72.28 77.63,72.42 77.63,72.63 77.77,72.77 78.05,72.77 78.19,72.63 78.19,72.42 78.34,72.28 78.62,72.28 78.76,72.42 78.76,72.63 78.91,72.77 79.19,72.77 79.33,72.63 79.33,72.42 79.47,72.28 79.76,72.28 79.9,72.42 79.9,72.63 80.04,72.77 80.33,72.77 80.47,72.63 80.47,72.42 80.61,72.28 80.9,72.28 81.04,72.42 81.04,72.63 81.18,72.77 81.49,72.77 81.63,72.63 81.63,72.42 81.77,72.28 82.06,72.28 82.2,72.42 82.2,72.63 82.34,72.77 82.68,72.77 83.42,73.51 89.23,73.51 93.44,77.72 100.49,77.72 101.16,77.05
  BOTTOM w0.076: UC1.AJ36 114.47,76.09 114.33,76.09 114.04,76.25 113.76,76.25 113.58,76.07 113.12,76.07 112.68,76.5 108.45,76.5 v2(108.3,76.64) v1(107.85,77.09)
  BOTTOM w0.14: JDIMM2.145 65.53,71.99 65.28,72.24 65.28,73.26 65.11,73.43 63.96,73.43 63.79,73.26 v1(63.79,72.34)
DDR_B_BG0: length 65.9
  IN3 w0.089: v1(118.61,82.66) 118.15,83.11 116.31,83.11 115.79,83.63 112.93,83.63 111.09,85.47 105.98,85.47
  IN3 w0.142: v1(62.36,84.09) 62.78,84.52 65.95,84.52 66.47,85.05 80.8,85.05 81.32,84.52 85.68,84.52 88.9,87.75 103.7,87.75 105.98,85.47
  BOTTOM w0.102: UC1.W29 118.61,82.6 118.61,82.65 v1(118.61,82.66)
  BOTTOM w0.14: JDIMM2.115 65.56,81.49 64.73,82.32 63.99,82.73 63.27,83.24 62.78,83.67 v1(62.36,84.09)
DDR_B_BG1: length 67.1
  IN3 w0.089: 109.1,83.84 110.28,83.84 111.62,82.51 116.23,82.51 116.43,82.3 118.43,82.3 118.47,82.26 118.67,82.26 v1(119.24,81.7)
  IN3 w0.142: 109.1,83.84 108.54,83.84 107.34,85.04 105.83,85.04 103.53,87.34 89.07,87.34 85.85,84.11 81.15,84.11 80.63,84.64 78.54,84.64 78.39,84.5 78.39,84.28 78.25,84.13 77.97,84.13 77.82,84.28 77.82,84.5 77.68,84.64 72.02,84.64 71.88,84.5 71.88,84.28 71.74,84.13 71.45,84.13 71.31,84.28 71.31,84.5 71.17,84.64 70.88,84.64 70.74,84.5 70.74,84.28 70.6,84.13 70.32,84.13 70.17,84.28 70.17,84.5 70.03,84.64 69.22,84.64 69.08,84.5 69.08,84.26 68.94,84.11 68.65,84.11 68.51,84.26 68.51,84.5 68.37,84.64 66.64,84.64 65.59,83.58 63.99,83.58 63.85,83.73 63.85,84.07 v1(63.88,84.09)
  BOTTOM w0.102: UC1.Y28 v1(119.24,81.7)
  BOTTOM w0.14: JDIMM2.113 65.7,81.99 64.68,83.02 64.68,83.3 v1(63.88,84.09)
DDR_B_CAS#: length 69.2
  IN3 w0.089: 99.22,73.9 99.78,73.9 100.41,74.53 104.22,74.53 104.56,74.86 106.57,74.86 106.65,74.79 108.66,74.79 v1(109.5,75.63)
  IN3 w0.142: v1(60.81,69.06) 60.81,68.81 60.67,68.66 59.6,68.66 59.41,68.85 59.41,69.58 59.26,69.72 58.66,69.72 58.52,69.58 58.52,68.08 58.66,67.94 61.38,67.94 61.75,67.58 83.33,67.58 83.82,68.07 86.9,68.07 88.51,69.68 94.21,69.68 98.42,73.9 99.22,73.9
  BOTTOM w0.076: UC1.AK34 115.28,75.61 114.8,75.61 114.69,75.56 114.45,75.56 114.33,75.61 114.15,75.61 114.04,75.56 112.92,75.56 112.49,76 109.87,76 v1(109.5,75.63)
  BOTTOM w0.14: v1(60.81,69.06) 60.27,68.53 59.9,68.53 59.19,69.24 JDIMM2.156
DDR_B_CKE0: length 65.3
  IN3 w0.089: 105.57,88.79 105.91,88.46 106.84,87.52 106.84,87.31 107.97,86.18 110.62,86.18 111.3,86.18 112.46,85.02 117.16,85.02 117.2,84.98 118.69,84.98 v1(119.24,84.43)
  IN3 w0.142: v1(63.98,86.01) 63.38,86.61 63.38,87 63.52,87.14 71.92,87.14 86.22,87.14 88.44,89.36 104.65,89.36 105.21,88.79 105.57,88.79
  BOTTOM w0.089: UC1.T28 v1(119.24,84.43)
  BOTTOM w0.14: JDIMM2.109 65.65,82.99 65.35,83.29 65.35,84.22 63.98,85.58 v1(63.98,86.01)
DDR_B_CKE1: length 66.7
  IN3 w0.089: v1(118.6,84.43) 118.23,84.8 116.9,84.8 116.86,84.84 112.39,84.84 111.23,86 107.64,86 106.4,87.24
  IN3 w0.142: v1(60.93,86.01) 61.36,85.58 65.51,85.58 66.66,86.73 86.39,86.73 88.61,88.95 104.3,88.95 104.87,88.38 105.55,88.38 106.4,87.54 106.4,87.24
  BOTTOM w0.089: UC1.T29 v1(118.6,84.43)
  BOTTOM w0.14: JDIMM2.110 59.09,82.74 59.6,83.24 59.6,84.67 v1(60.93,86.01)
DDR_B_CKE2: length 1.4
  TOP w0.14: TP10.1 119.86,83.35 v1(119.86,83.5)
  BOTTOM w0.076: UC1.V28 119.51,83.15 v1(119.86,83.5)
DDR_B_CKE3: length 1.1
  TOP w0.14: TP12.1 118.91,83.75 v1(119.16,83.5)
  BOTTOM w0.076: UC1.V29 118.86,83.2 v1(119.16,83.5)
DDR_B_CLK0: length 71.9
  IN3 w0.089: v1(118.6,78.05) 118.65,78.1 118.65,78.27 118.56,78.35 117.5,78.35 117.44,78.41 117.1,78.41 117.1,78.41 115.6,78.41 114.84,77.66 113.35,77.66 113.03,77.98 113.03,78.37 112.42,78.98 111.54,78.98 111.54,78.98 111.4,78.98 110.5,78.08 103.96,78.08 103.95,78.09 103.33,78.09 103.22,77.98 102.35,77.98 102.23,78.1 102.21,78.1
  IN3 w0.117: 102.21,78.1 101.13,79.18 90.82,79.18 86.6,74.97 83.21,74.97 82.97,75.21 82.97,75.94 82.85,76.06 82.51,76.06 82.38,75.93 82.38,74.66 82.14,74.42 81.15,74.42 80.91,74.66 80.91,74.81 80.79,74.93 80.35,74.93 80.24,74.81 80.24,74.47 80,74.23 79.47,74.23 79.23,74.47 79.23,74.81 79.12,74.93 78.77,74.93 78.65,74.81 78.65,74.47 78.41,74.23 77.89,74.23 77.65,74.47 77.65,74.81 77.53,74.93 77.13,74.93 77.01,74.81 77.01,74.67 76.77,74.43 76.25,74.43 76.01,74.67 76.01,74.81 75.89,74.93 75.54,74.93 75.42,74.81 75.42,74.67 75.18,74.43 74.66,74.43 74.42,74.67 74.42,74.81 74.3,74.93 73.95,74.93 73.83,74.81 73.83,74.67 73.59,74.43 73.07,74.43 72.83,74.67 72.83,74.81 72.71,74.93 72.26,74.93 72.14,74.81 72.14,74.47 71.9,74.23 71.38,74.23 71.14,74.47 71.14,74.81 71.02,74.93 70.78,74.93 70,74.15 67.4,74.15 67.05,73.81 65.73,73.81 65.39,74.15 64.86,74.15 64.51,73.81 64.07,73.81 63.83,74.05 63.83,74.55 v1(63.6,74.78)
  BOTTOM w0.089: UC1.AF29 v1(118.6,78.05)
  BOTTOM w0.112: v1(63.6,74.78) 63.87,75.05 63.87,75.45 64.16,75.74 65.09,75.74 65.19,75.84 65.37,75.84 65.51,75.99 JDIMM2.137
DDR_B_CLK1: length 71.3
  IN3 w0.089: v1(118.61,78.96) 118.72,79.07 118.72,79.19 118.61,79.31 117.5,79.31 117.48,79.33 116.2,79.33 116.03,79.5 111.4,79.5 110.35,78.45 104.11,78.45 103.85,78.71 103.85,78.75 103.81,78.79
  IN3 w0.117: 103.81,78.79 103.11,78.79 103.1,78.79 102.7,78.79 101.48,80.01 90.47,80.01 87.35,76.89 86.62,76.89 86.5,76.78 86.5,76.04 86.26,75.8 85.73,75.8 85.49,76.04 85.49,76.78 85.38,76.89 84.93,76.89 84.81,76.78 84.81,76.04 84.57,75.8 84.04,75.8 83.8,76.04 83.8,76.78 83.69,76.89 82.16,76.89 81.03,75.76 70.43,75.76 70.07,75.4 69.56,75.4 69.15,74.99 68.17,74.99 67.76,75.4 67.11,75.4 66.99,75.29 66.99,74.93 66.75,74.69 66.23,74.69 65.99,74.93 65.99,75.29 65.87,75.4 61.64,75.4 61.53,75.29 61.53,75.15 61.66,75.02 61.96,75.02 62.08,74.9 v1(62.08,74.78)
  BOTTOM w0.076: UC1.AE29 118.84,78.54 v1(118.61,78.96)
  BOTTOM w0.112: JDIMM2.138 59.13,75.74 59.24,75.62 61.48,75.62 61.72,75.38 61.72,75.13 v1(62.08,74.78)
DDR_B_CLK#0: length 71.9
  IN3 w0.089: 102.36,78.25 102.44,78.17 103.14,78.17 103.25,78.28 104.03,78.28 104.03,78.27 110.42,78.27 111.32,79.17 111.46,79.17 112.5,79.17 113.22,78.45 113.22,78.06 113.43,77.85 114.76,77.85 115.52,78.6 117.18,78.6 117.18,78.6 117.52,78.6 117.58,78.54 118.64,78.54 118.85,78.34 118.95,78.34 v1(119.24,78.05)
  IN3 w0.117: 102.36,78.25 101.22,79.39 90.73,79.39 86.52,75.18 83.3,75.18 83.18,75.29 83.18,76.03 82.94,76.27 82.42,76.27 82.17,76.02 82.17,74.75 82.06,74.63 81.24,74.63 81.12,74.75 81.12,74.9 80.88,75.14 80.27,75.14 80.03,74.9 80.03,74.56 79.91,74.44 79.56,74.44 79.44,74.56 79.44,74.9 79.2,75.14 78.68,75.14 78.44,74.9 78.44,74.56 78.32,74.44 77.97,74.44 77.86,74.56 77.86,74.9 77.62,75.14 77.04,75.14 76.8,74.9 76.8,74.76 76.69,74.65 76.34,74.65 76.22,74.76 76.22,74.9 75.98,75.14 75.45,75.14 75.21,74.9 75.21,74.76 75.1,74.65 74.75,74.65 74.63,74.76 74.63,74.9 74.39,75.14 73.86,75.14 73.62,74.9 73.62,74.76 73.51,74.65 73.16,74.65 73.04,74.76 73.04,74.9 72.8,75.14 72.17,75.14 71.93,74.9 71.93,74.56 71.82,74.44 71.47,74.44 71.35,74.56 71.35,74.9 71.11,75.14 70.69,75.14 69.91,74.36 67.31,74.36 66.97,74.02 65.82,74.02 65.47,74.36 64.77,74.36 64.43,74.02 64.16,74.02 64.04,74.14 64.04,74.66 64.16,74.78 v1(64.36,74.78)
  BOTTOM w0.089: UC1.AF28 v1(119.24,78.05)
  BOTTOM w0.112: v1(64.36,74.78) 64.09,75.05 64.09,75.36 64.25,75.52 65.18,75.52 65.29,75.62 65.44,75.62 65.57,75.49 JDIMM2.139
DDR_B_CLK#1: length 71.3
  IN3 w0.089: v1(119.24,78.97) 119.22,78.97 118.69,79.5 117.58,79.5 117.56,79.52 116.28,79.52 116.11,79.69 111.32,79.69 110.27,78.64 104.19,78.64 104.04,78.79 104.04,78.88 103.94,78.98 103.93,78.98 103.9,79 103.81,79
  IN3 w0.117: 103.81,79 103.2,79 103.19,79.01 102.78,79.01 101.57,80.22 90.38,80.22 87.26,77.1 86.53,77.1 86.29,76.86 86.29,76.13 86.17,76.01 85.82,76.01 85.7,76.13 85.7,76.86 85.46,77.1 84.84,77.1 84.6,76.86 84.6,76.13 84.48,76.01 84.13,76.01 84.01,76.13 84.01,76.86 83.77,77.1 82.08,77.1 80.95,75.97 70.34,75.97 69.98,75.61 69.48,75.61 69.06,75.2 68.26,75.2 67.84,75.61 67.02,75.61 66.78,75.37 66.78,75.02 66.66,74.9 66.31,74.9 66.2,75.02 66.2,75.37 65.96,75.61 61.56,75.61 61.32,75.37 v1(61.32,74.78)
  BOTTOM w0.089: UC1.AE28 119.49,78.54 v1(119.24,78.97)
  BOTTOM w0.112: JDIMM2.140 59.13,75.24 59.29,75.4 61.39,75.4 61.5,75.29 61.5,74.96 v1(61.32,74.78)
DDR_B_CS#0: length 67.5
  IN3 w0.089: v1(110.77,75.63) 109.95,76.45 109.37,76.45 108.94,76.03 103.82,76.03 103.67,75.88 100.25,75.88 99.88,76.25
  IN3 w0.142: 99.88,76.25 94.05,76.25 93.73,75.94 93.73,75.74 94.18,75.29 94.18,75.09 93.98,74.89 93.78,74.89 93.33,75.34 93.13,75.34 92.93,75.14 92.93,74.94 93.42,74.45 93.42,74.35 93.42,74.25 93.22,74.04 93.02,74.04 92.53,74.54 92.33,74.54 89.83,72.04 84.03,72.04 82.23,70.24 81.89,70.24 81.75,70.39 81.75,70.67 81.6,70.81 81.32,70.81 81.18,70.67 81.18,70.39 81.03,70.24 80.71,70.24 80.56,70.39 80.56,70.67 80.42,70.81 80.14,70.81 80,70.67 80,70.39 79.85,70.24 79.57,70.24 79.43,70.39 79.43,70.67 79.28,70.81 79,70.81 78.86,70.67 78.86,70.39 78.72,70.24 78.43,70.24 78.29,70.39 78.29,70.67 78.15,70.81 77.86,70.81 77.72,70.67 77.72,70.39 77.58,70.24 72.13,70.24 71.99,70.39 71.99,70.67 71.84,70.81 71.56,70.81 71.42,70.67 71.42,70.39 71.28,70.24 70.99,70.24 70.85,70.39 70.85,70.67 70.71,70.81 70.42,70.81 70.28,70.67 70.28,70.39 70.14,70.24 69.26,70.24 69.12,70.39 69.12,70.67 68.97,70.81 68.69,70.81 68.55,70.67 68.55,70.39 68.4,70.24 67.06,70.24 66.91,70.39 66.91,70.67 66.77,70.81 66.49,70.81 66.34,70.67 66.34,70.39 66.2,70.24 65.92,70.24 65.78,70.39 65.78,70.67 65.63,70.81 65.35,70.81 65.21,70.67 65.21,70.39 65.06,70.24 64.12,70.24 63.86,70.51 v1(63.86,70.78)
  BOTTOM w0.076: UC1.AL37 113.82,74.79 113.04,74.79 112.9,74.64 112.32,74.64 111.9,75.06 111.33,75.06 v1(110.77,75.63)
  BOTTOM w0.14: v1(63.86,70.78) 64.38,71.31 65.19,71.31 65.5,70.99 JDIMM2.149
DDR_B_CS#1: length 70.2
  IN3 w0.089: 99.22,74.95 99.69,74.95 99.98,75.24 104.17,75.24 104.3,75.37 106.57,75.37 106.7,75.24 107.84,75.24 v1(108.23,75.63)
  IN3 w0.142: v1(63.86,69.06) 64.28,68.64 65.12,68.64 65.26,68.78 65.26,68.8 65.41,68.94 65.69,68.94 65.83,68.8 65.83,68.78 65.97,68.64 66.26,68.64 66.4,68.78 66.4,68.8 66.54,68.94 66.83,68.94 66.97,68.8 66.97,68.78 67.11,68.64 70.3,68.64 70.44,68.78 70.44,68.8 70.59,68.94 70.87,68.94 71.01,68.8 71.01,68.78 71.15,68.64 71.44,68.64 71.58,68.78 71.58,68.8 71.72,68.94 72.01,68.94 72.15,68.8 72.15,68.78 72.29,68.64 77.91,68.64 78.05,68.78 78.05,68.8 78.19,68.94 78.48,68.94 78.62,68.8 78.62,68.78 78.76,68.64 79.05,68.64 79.19,68.78 79.19,68.8 79.33,68.94 79.62,68.94 79.76,68.8 79.76,68.78 79.9,68.64 82.89,68.64 83.3,69.05 83.3,69.42 83.51,69.63 83.88,69.63 84.1,69.85 84.1,70.22 84.32,70.44 84.69,70.44 84.99,70.74 91.04,70.74 91.18,70.88 91.18,71.23 91.32,71.37 91.6,71.37 91.75,71.23 91.75,70.88 91.89,70.74 92.17,70.74 92.31,70.88 92.31,72.43 92.46,72.58 92.74,72.58 92.88,72.43 92.88,70.88 93.03,70.74 93.42,70.74 93.78,71.1 93.78,71.3 93.42,71.66 93.42,71.86 93.62,72.06 93.82,72.06 94.18,71.7 94.38,71.7 94.65,71.97 94.65,72.17 94.01,72.8 94.01,73 94.22,73.2 94.42,73.2 95.05,72.57 95.25,72.57 95.51,72.83 95.51,73.03 94.88,73.66 94.88,73.86 95.08,74.06 95.28,74.06 95.91,73.43 96.11,73.43 97.64,74.95 99.22,74.95
  BOTTOM w0.076: UC1.AL35 114.9,74.37 114.27,74.37 114.07,74.26 113.69,74.26 113.51,74.45 113.17,74.45 113.03,74.3 112.18,74.3 111.77,74.71 109.15,74.71 v1(108.23,75.63)
  BOTTOM w0.14: v1(63.86,69.06) 64.52,68.4 64.8,68.4 65.4,68.99 JDIMM2.157
DDR_B_D0: length 80.3
  IN3 w0.089: v1(122.72,87.84) 122.97,88.11 123.14,88.41 123.26,88.74 123.26,88.76 123.3,88.8 123.3,89.17 123.46,89.33 123.46,89.59 123.46,89.87 123.46,90.23 120.91,92.78 120.91,94.61 118.96,96.56 118.96,99.35 119.01,99.4 119.01,99.57
  IN3 w0.117: 119.01,99.57 119.01,102.34 115.66,105.69 104.02,105.69 102.98,104.65 61.24,104.65 v1(60.05,103.46)
  BOTTOM w0.102: UC1.J22 v1(122.72,87.84)
  BOTTOM w0.112: JDIMM2.28 58.25,103.24 59.41,103.24 59.64,103.46 v1(60.05,103.46)
DDR_B_D1: length 82.5
  IN3 w0.089: 117.26,93.67 118.58,92.35 119.14,92.35 121.22,90.27 121.22,89.01 v1(120.68,88.47)
  IN3 w0.117: v1(64.62,100.73) 64.62,101.16 64.73,101.28 66.27,101.28 66.39,101.16 66.39,100.76 66.5,100.64 66.74,100.64 66.86,100.76 66.86,102.04 66.97,102.16 67.21,102.16 67.32,102.04 67.32,100.76 67.44,100.64 67.67,100.64 67.79,100.76 67.79,101.46 67.91,101.57 68.14,101.57 68.26,101.46 68.26,100.76 68.37,100.64 68.61,100.64 68.72,100.76 68.72,101.74 68.84,101.85 69.08,101.85 69.19,101.74 69.19,100.76 69.31,100.64 69.54,100.64 69.66,100.76 69.66,101.71 69.78,101.83 70.01,101.83 70.13,101.71 70.13,100.76 70.24,100.64 70.48,100.64 70.59,100.76 70.59,101.89 70.71,102 70.94,102 71.06,101.89 71.06,100.76 71.18,100.64 71.41,100.64 71.53,100.76 71.53,101.86 71.67,102 71.91,102 72.02,101.89 72.02,101.39 72.14,101.28 77.73,101.28 77.85,101.16 77.85,100.76 77.97,100.64 78.2,100.64 78.32,100.76 78.32,101.16 78.43,101.28 78.67,101.28 78.78,101.16 78.78,100.76 78.9,100.64 79.13,100.64 79.25,100.76 79.25,101.16 79.37,101.28 79.6,101.28 79.72,101.16 79.72,100.76 79.84,100.64 80.07,100.64 80.19,100.76 80.19,101.16 80.3,101.28 107.62,101.28 111.35,97.54 113.51,97.54 117.26,93.8 117.26,93.67
  BOTTOM w0.076: UC1.H25 v1(120.68,88.47)
  BOTTOM w0.112: v1(64.62,100.73) 65.03,100.73 65.29,100.99 JDIMM2.37
DDR_B_D2: length 79.5
  IN3 w0.089: v1(122.72,89.11) 122.72,89.2 123.1,89.58 123.1,89.63 123.1,89.63 123.1,90.08 119.41,93.77 119.41,94.29 118,95.71 118,98.77
  IN3 w0.117: v1(63.1,103.46) 63.64,104.01 103.58,104.01 103.7,104.13 103.7,104.46 103.81,104.58 104.05,104.58 104.16,104.46 104.16,104.13 104.28,104.01 104.51,104.01 104.63,104.13 104.63,104.94 104.75,105.05 104.98,105.05 105.1,104.94 105.1,104.13 105.22,104.01 105.45,104.01 105.57,104.13 105.57,104.94 105.68,105.05 115.39,105.05 117.73,102.71 117.73,99.04 118,98.77
  BOTTOM w0.102: v1(122.72,89.11) UC1.G22
  BOTTOM w0.112: v1(63.1,103.46) 63.57,102.99 66.45,102.99 JDIMM2.29
DDR_B_D3: length 79.3
  IN3 w0.089: 118.69,99.57 118.69,99.44 118.78,99.35 118.78,96.48 120.73,94.54 120.73,92.71 123.28,90.16 123.28,89.56 123.28,89.55 123.28,89.51 123.12,89.36 123.12,88.88 v1(122.72,88.47)
  IN3 w0.117: v1(61.57,103.46) 62.44,104.33 103.11,104.33 104.15,105.37 115.52,105.37 118.69,102.21 118.69,99.57
  BOTTOM w0.102: UC1.H22 v1(122.72,88.47)
  BOTTOM w0.112: v1(61.57,103.46) 60.79,104.24 JDIMM2.24
DDR_B_D4: length 83
  IN3 w0.089: 116.37,93.78 116.37,93.15 117.63,91.89 118.9,91.89 120.63,90.15 v1(120.63,89.8)
  IN3 w0.117: 116.37,93.78 113.25,96.9 111.09,96.9 108.17,99.82 99.48,99.82 99.36,99.94 99.36,100.52 99.24,100.64 99.01,100.64 98.89,100.52 98.89,99.94 98.78,99.82 98.54,99.82 98.43,99.94 98.43,100.52 98.31,100.64 98.08,100.64 97.96,100.52 97.96,99.94 97.84,99.82 97.55,99.82 97.43,99.94 97.43,100.52 97.32,100.64 97.08,100.64 96.97,100.52 96.97,99.94 96.85,99.82 96.62,99.82 96.5,99.94 96.5,100.52 96.38,100.64 96.15,100.64 96.03,100.52 96.03,99.94 95.91,99.82 95.68,99.82 95.56,99.94 95.56,100.52 95.45,100.64 95.21,100.64 95.1,100.52 95.1,99.94 94.98,99.82 94.75,99.82 94.63,99.94 94.63,100.52 94.51,100.64 94.28,100.64 94.16,100.52 94.16,99.94 94.05,99.82 93.81,99.82 93.69,99.94 93.69,100.52 93.58,100.64 93.34,100.64 93.23,100.52 93.23,99.94 93.11,99.82 92.88,99.82 92.76,99.94 92.76,100.52 92.64,100.64 92.41,100.64 92.29,100.52 92.29,99.94 92.18,99.82 91.94,99.82 91.83,99.94 91.83,100.52 91.71,100.64 91.47,100.64 91.36,100.52 91.36,99.94 91.24,99.82 91.01,99.82 90.89,99.94 90.89,100.52 90.77,100.64 90.54,100.64 90.42,100.52 90.42,99.94 90.31,99.82 90.07,99.82 89.96,99.94 89.96,100.52 89.84,100.64 81.6,100.64 80.94,99.98 62.32,99.98 v1(61.57,100.73)
  BOTTOM w0.076: UC1.F25 v1(120.63,89.8)
  BOTTOM w0.112: JDIMM2.42 60.58,99.74 v1(61.57,100.73)
DDR_B_D5: length 81.4
  IN3 w0.089: v1(120.68,87.84) 120.26,88.26 120.26,89.95 119.73,90.48 118.62,90.48 116.12,92.99 116.12,93.53
  IN3 w0.117: v1(60.05,100.73) 61.12,99.66 81.07,99.66 81.74,100.32 82.03,100.32 82.15,100.2 82.15,99.62 82.26,99.5 82.5,99.5 82.62,99.62 82.62,100.2 82.73,100.32 82.97,100.32 83.08,100.2 83.08,99.62 83.2,99.5 83.43,99.5 83.55,99.62 83.55,100.2 83.67,100.32 83.9,100.32 84.02,100.2 84.02,99.62 84.13,99.5 84.37,99.5 84.48,99.62 84.48,100.2 84.6,100.32 84.84,100.32 84.95,100.2 84.95,99.62 85.07,99.5 85.3,99.5 85.42,99.62 85.42,100.2 85.54,100.32 85.77,100.32 85.89,100.2 85.89,99.62 86,99.5 86.24,99.5 86.35,99.62 86.35,100.2 86.47,100.32 86.7,100.32 86.82,100.2 86.82,99.62 86.94,99.5 87.17,99.5 87.29,99.62 87.29,100.2 87.41,100.32 87.64,100.32 87.76,100.2 87.76,99.62 87.87,99.5 88.12,99.5 88.23,99.62 88.23,100.2 88.35,100.32 88.58,100.32 88.7,100.2 88.7,99.62 88.82,99.5 89.05,99.5 89.17,99.62 89.17,100.2 89.29,100.32 89.52,100.32 89.64,100.2 89.64,99.62 89.75,99.5 107.86,99.5 110.77,96.58 113.06,96.58 116.12,93.53
  BOTTOM w0.102: UC1.J25 v1(120.68,87.84)
  BOTTOM w0.112: JDIMM2.38 59.31,100.74 59.32,100.73 v1(60.05,100.73)
DDR_B_D6: length 80.1
  IN3 w0.089: 117.02,93.58 118.46,92.14 118.9,92.14 121.01,90.03 121.01,89.43 v1(120.68,89.11)
  IN3 w0.117: 117.02,93.58 113.38,97.22 111.22,97.22 107.49,100.96 106.93,100.96 106.81,100.84 106.81,100.26 106.69,100.14 106.46,100.14 106.34,100.26 106.34,100.84 106.22,100.96 105.99,100.96 105.87,100.84 105.87,100.26 105.76,100.14 105.52,100.14 105.41,100.26 105.41,100.84 105.29,100.96 105.06,100.96 104.94,100.84 104.94,100.26 104.82,100.14 104.59,100.14 104.47,100.26 104.47,100.84 104.36,100.96 104.12,100.96 104,100.84 104,100.26 103.89,100.14 103.65,100.14 103.54,100.26 103.54,100.84 103.42,100.96 103.19,100.96 103.07,100.84 103.07,100.26 102.95,100.14 102.72,100.14 102.6,100.26 102.6,100.84 102.49,100.96 102.25,100.96 102.14,100.84 102.14,100.26 102.02,100.14 101.78,100.14 101.67,100.26 101.67,100.84 101.55,100.96 101.32,100.96 101.2,100.84 101.2,100.26 101.08,100.14 100.85,100.14 100.73,100.26 100.73,100.84 100.62,100.96 100.38,100.96 100.27,100.84 100.27,100.26 100.15,100.14 99.92,100.14 99.8,100.26 99.8,100.84 99.68,100.96 81.47,100.96 80.81,100.3 66.07,100.3 65.95,100.41 65.95,100.84 65.83,100.96 65.6,100.96 65.48,100.84 65.48,100.41 65.37,100.3 63.53,100.3 v1(63.09,100.73)
  BOTTOM w0.076: UC1.G25 v1(120.68,89.11)
  BOTTOM w0.112: v1(63.09,100.73) 63.84,99.99 66.45,99.99 JDIMM2.41
DDR_B_D7: length 79.3
  IN3 w0.089: v1(122.72,89.74) 122.72,90.11 119.03,93.79 119.03,94.24 117.76,95.51 117.76,98.56 117.7,98.62
  IN3 w0.117: v1(64.62,103.46) 64.79,103.63 105.77,103.63 105.89,103.75 105.89,104.46 106,104.58 106.24,104.58 106.35,104.46 106.35,103.75 106.47,103.63 106.7,103.63 106.82,103.75 106.82,104.62 106.94,104.73 107.17,104.73 107.29,104.62 107.29,103.75 107.41,103.63 107.65,103.63 107.77,103.75 107.77,104.62 107.88,104.73 108.12,104.73 108.23,104.62 108.23,103.75 108.35,103.63 109.17,103.63 109.29,103.75 109.29,104.62 109.41,104.73 109.64,104.73 109.76,104.62 109.76,103.75 109.87,103.63 110.2,103.63 111.3,104.73 115.26,104.73 117.41,102.58 117.41,98.91 117.7,98.62
  BOTTOM w0.102: UC1.F22 v1(122.72,89.74)
  BOTTOM w0.112: v1(64.62,103.46) 65.15,103.99 JDIMM2.25
DDR_B_D8: length 82.7
  IN3 w0.117: v1(124.34,94.73) 123.93,95.14 123.93,100.86 123.93,101.3 116.79,108.43 88.64,108.43 87.6,107.39 82.71,107.39 82.59,107.51 82.59,107.89 82.47,108.01 82.24,108.01 82.12,107.89 82.12,107.51 82,107.39 81.77,107.39 81.65,107.51 81.65,108.32 81.53,108.43 62.02,108.43 v1(61.57,108.89)
  BOTTOM w0.076: v1(124.34,94.73) 124.34,94.11 123.59,93.35 123.59,93.05 123.78,92.86 123.78,92.47 123.67,92.27 123.67,91.67 123.67,91.33 123.54,91.06 UC1.D22
  BOTTOM w0.112: v1(61.57,108.89) 60.92,108.24 JDIMM2.8
DDR_B_D9: length 82.4
  IN3 w0.117: v1(64.62,108.89) 64.75,108.75 82.89,108.75 83.01,108.64 83.01,107.83 83.12,107.71 83.36,107.71 83.47,107.83 83.47,108.64 83.59,108.75 83.84,108.75 83.95,108.64 83.95,107.83 84.07,107.71 84.3,107.71 84.42,107.83 84.42,108.64 84.54,108.75 84.77,108.75 84.89,108.64 84.89,107.83 85,107.71 85.24,107.71 85.35,107.83 85.35,108.64 85.47,108.75 85.7,108.75 85.82,108.64 85.82,107.83 85.94,107.71 87.46,107.71 88.5,108.75 117.06,108.75 124.49,101.31 124.49,98.06 v1(124.34,97.91)
  BOTTOM w0.076: 123.66,97.22 123.33,96.89 123.33,95.87 123.25,95.79 123.25,95.77 123.25,93.71 123.09,93.55 123.09,92.53 123.13,92.42 123.13,92.41 123.14,92.37 123.14,92.22 123.13,92.18 123.13,92.18 123.09,92.06 123.09,91.88 123.15,91.7 123.15,91.69 123.19,91.58 UC1.C22
  BOTTOM w0.112: v1(64.62,108.89) 65.01,108.49 JDIMM2.7 ; 123.66,97.22 v1(124.34,97.91)
DDR_B_D10: length 82.2
  IN3 w0.117: v1(63.03,105.93) 63.77,106.66 80.72,106.66 81.25,106.13 88.48,106.13 88.6,106.25 88.6,106.56 88.71,106.68 88.95,106.68 89.06,106.56 89.06,106.25 89.18,106.13 89.42,106.13 89.53,106.25 89.53,107.06 89.65,107.18 89.88,107.18 90,107.06 90,106.25 90.12,106.13 90.35,106.13 90.47,106.25 90.47,107.06 90.58,107.18 90.82,107.18 90.93,107.06 90.93,106.25 91.05,106.13 91.28,106.13 91.4,106.25 91.4,107.06 91.52,107.18 116.27,107.18 122.4,101.05 122.4,99.51 122.61,99.3 122.61,99.1 v1(122.7,99.01)
  BOTTOM w0.076: 122.29,98.59 121.67,97.97 121.67,95.32 121.59,95.25 121.59,93.57 121.81,93.35 121.81,93.03 121.62,92.84 121.62,92.47 121.73,92.26 121.73,91.9 UC1.C24
  BOTTOM w0.112: 122.29,98.59 v1(122.7,99.01) ; JDIMM2.21 63.97,104.99 v1(63.03,105.93)
DDR_B_D11: length 82.3
  IN3 w0.117: v1(122.7,96.47) 121.66,97.51 121.66,98.63 121.65,98.65 121.65,98.77 121.44,98.97 121.44,100.65 115.87,106.22 103.8,106.22 102.76,105.17 101.48,105.17 101.37,105.29 101.37,106.1 101.25,106.22 101.02,106.22 100.9,106.1 100.9,105.29 100.78,105.17 100.55,105.17 100.43,105.29 100.43,106.1 100.31,106.22 100.08,106.22 99.96,106.1 99.96,105.29 99.85,105.17 99.54,105.17 99.42,105.29 99.42,105.48 99.31,105.6 99.07,105.6 98.96,105.48 98.96,105.29 98.84,105.17 60.74,105.17 v1(59.99,105.93)
  BOTTOM w0.076: UC1.D24 122.78,90.67 122.82,90.71 122.99,90.88 122.99,91.12 122.99,91.67 122.92,91.85 122.92,92.09 122.96,92.21 122.96,92.39 122.92,92.5 122.92,93.62 123.08,93.78 123.08,95.84 123.08,96.09 v1(122.7,96.47)
  BOTTOM w0.112: v1(59.99,105.93) 59.3,105.24 JDIMM2.20
DDR_B_D12: length 81.3
  IN3 w0.117: v1(124.34,96.64) 124.53,96.64 124.81,96.92 124.81,101.58 124.22,102.17 124.22,103.05 120.15,107.12 119.27,107.12 117.32,109.07 87.91,109.07 87.8,108.96 87.8,108.76 87.68,108.64 87.44,108.64 87.33,108.76 87.33,108.96 87.21,109.07 86.98,109.07 86.86,108.96 86.86,108.38 86.74,108.26 86.51,108.26 86.39,108.38 86.39,108.96 86.28,109.07 85,109.07 84.49,109.58 63.79,109.58 v1(63.09,108.89)
  BOTTOM w0.076: UC1.A22 123.27,92.86 123.27,92.9 123.26,92.91 123.26,93.49 123.41,93.64 123.41,95.7 124.29,96.59
  BOTTOM w0.112: 124.29,96.59 v1(124.34,96.64) ; JDIMM2.3 65.31,109.49 65.03,109.77 63.98,109.77 v1(63.09,108.89)
DDR_B_D13: length 81.9
  IN3 w0.117: v1(124.34,96) 125.13,96.79 125.13,101.87 124.54,102.46 124.54,103.18 120.28,107.44 119.57,107.44 117.61,109.39 85.13,109.39 84.62,109.9 61.06,109.9 v1(60.05,108.89)
  BOTTOM w0.076: UC1.B22 123.47,92.24 123.5,92.31 123.5,92.31 123.61,92.51 123.61,92.79 123.42,92.98 123.42,93.42 123.58,93.57 123.58,94.97 v1(124.34,96)
  BOTTOM w0.112: JDIMM2.4 59.69,109.24 v1(60.05,108.89)
DDR_B_D14: length 81.5
  IN3 w0.117: v1(61.51,105.93) 61.94,105.49 95.7,105.49 95.82,105.61 95.82,105.73 95.94,105.85 96.17,105.85 96.29,105.73 96.29,105.61 96.4,105.49 96.65,105.49 96.77,105.61 96.77,106.42 96.89,106.54 97.12,106.54 97.24,106.42 97.24,105.61 97.35,105.49 97.59,105.49 97.7,105.61 97.7,106.42 97.82,106.54 98.06,106.54 98.17,106.42 98.17,105.61 98.29,105.49 98.52,105.49 98.64,105.61 98.64,106.42 98.76,106.54 98.99,106.54 99.11,106.42 99.11,106.03 99.22,105.92 99.46,105.92 99.57,106.03 99.57,106.42 99.69,106.54 116.01,106.54 121.76,100.78 121.76,99.24 121.97,99.03 121.97,98.78 121.98,98.76 121.98,97.83 v1(122.7,97.11)
  BOTTOM w0.076: v1(122.7,97.11) 122.32,96.72 122.32,95.31 121.93,94.93 121.93,93.69 122.14,93.49 122.14,92.89 UC1.A24
  BOTTOM w0.112: JDIMM2.16 58.25,106.24 59.31,106.24 59.79,106.72 60.71,106.72 v1(61.51,105.93)
DDR_B_D15: length 82.1
  IN3 w0.117: v1(122.7,97.74) 122.3,98.14 122.3,98.9 122.29,98.91 122.29,99.17 122.08,99.37 122.08,100.91 116.14,106.86 96.52,106.86 96.41,106.74 96.41,106.29 96.29,106.17 96.05,106.17 95.94,106.29 95.94,106.74 95.82,106.86 95.59,106.86 95.47,106.74 95.47,105.93 95.35,105.81 95.12,105.81 95,105.93 95,106.74 94.89,106.86 94.65,106.86 94.54,106.74 94.54,105.93 94.42,105.81 94.18,105.81 94.06,105.93 94.06,106.74 93.94,106.86 93.71,106.86 93.59,106.74 93.59,105.93 93.47,105.81 93.24,105.81 93.12,105.93 93.12,106.74 93.01,106.86 92.77,106.86 92.66,106.74 92.66,105.93 92.54,105.81 92.31,105.81 92.19,105.93 92.19,106.74 92.07,106.86 91.84,106.86 91.72,106.74 91.72,105.93 91.6,105.81 81.12,105.81 80.59,106.34 78.65,106.34 78.53,106.23 78.53,105.93 78.41,105.81 78.18,105.81 78.06,105.93 78.06,106.23 77.95,106.34 64.98,106.34 v1(64.56,105.93)
  BOTTOM w0.076: UC1.B24 121.93,92.23 121.78,92.51 121.78,92.78 121.97,92.97 121.97,93.42 121.77,93.62 121.77,95.05 121.99,95.27 121.99,97.03 v1(122.7,97.74)
  BOTTOM w0.112: v1(64.56,105.93) 64.62,105.99 JDIMM2.17
DDR_B_D16: length 66.6
  IN3 w0.089: 114.68,93.05 114.68,92.67 115.71,91.64 116.26,91.64 117.03,90.87 117.03,90.22 v1(117.3,89.95)
  IN3 w0.117: 114.68,93.05 114.68,93.45 112.79,95.35 109.72,95.35 107.46,97.61 70.48,97.61 70.36,97.73 70.36,98.12 70.24,98.24 70.01,98.24 69.89,98.12 69.89,97.73 69.77,97.61 68.93,97.61 68.82,97.73 68.82,98.11 68.7,98.23 68.47,98.23 68.35,98.11 68.35,97.73 68.23,97.61 66.78,97.61 66.66,97.73 66.66,98.1 66.54,98.22 66.31,98.22 66.19,98.1 66.19,97.73 66.08,97.61 65.84,97.61 65.73,97.73 65.73,98.1 65.61,98.22 65.38,98.22 65.26,98.1 65.26,97.73 65.14,97.61 63.63,97.61 v1(63.09,98.15)
  BOTTOM w0.089: v1(117.3,89.95) 117.3,89.97 UC1.G31
  BOTTOM w0.112: JDIMM2.45 63.94,98.99 v1(63.09,98.15)
DDR_B_D17: length 68.6
  IN3 w0.089: v1(116.71,89.91) 116.56,89.91 115.76,90.71 115.76,91.1 113.79,93.06 113.79,93.6
  IN3 w0.117: 113.79,93.6 113.79,93.89 112.66,95.03 109.41,95.03 107.15,97.29 74.23,97.29 74.12,97.17 74.12,97.08 74,96.96 73.77,96.96 73.65,97.08 73.65,97.17 73.53,97.29 73.3,97.29 73.18,97.17 73.18,96.92 73.07,96.8 72.83,96.8 72.72,96.92 72.72,97.17 72.6,97.29 71.48,97.29 71.37,97.17 71.37,96.92 71.25,96.8 71.02,96.8 70.9,96.92 70.9,97.17 70.78,97.29 70.55,97.29 70.43,97.17 70.43,96.92 70.31,96.8 70.08,96.8 69.96,96.92 69.96,97.17 69.85,97.29 68.88,97.29 68.76,97.17 68.76,96.94 68.63,96.8 68.41,96.8 68.3,96.92 68.3,97.17 68.18,97.29 67.24,97.29 67.13,97.17 67.13,96.92 67.01,96.8 66.78,96.8 66.66,96.92 66.66,97.17 66.54,97.29 66.31,97.29 66.19,97.17 66.19,96.92 66.07,96.8 65.84,96.8 65.72,96.92 65.72,97.17 65.61,97.29 65.37,97.29 65.26,97.17 65.26,96.92 65.14,96.8 64.91,96.8 64.79,96.92 64.79,97.17 64.67,97.29 62.43,97.29 v1(61.57,98.15)
  BOTTOM w0.102: v1(116.71,89.91) 116.71,89.91 116.71,89.89 116.91,89.69 UC1.G32
  BOTTOM w0.112: JDIMM2.46 60.98,98.74 v1(61.57,98.15)
DDR_B_D18: length 67.6
  IN3 w0.089: 108.38,92.76 111.42,92.76 115.48,88.7 116.19,88.7 116.43,88.45 116.92,88.45 117.08,88.62 118.23,88.62 v1(118.6,88.99)
  IN3 w0.117: 108.38,92.76 105.97,95.17 87.09,95.17 86.07,94.15 62.44,94.15 62.32,94.27 62.32,94.75 62.21,94.86 61.97,94.86 61.86,94.75 61.86,94.27 61.74,94.15 61.3,94.15 61.12,94.33 61.12,95.03 v1(61.57,95.48)
  BOTTOM w0.089: UC1.H29 v1(118.6,88.99)
  BOTTOM w0.112: v1(61.57,95.48) 60.83,94.74 JDIMM2.62
DDR_B_D19: length 67.8
  IN3 w0.089: 108.3,92.39 111.54,92.39 115.42,88.51 116.12,88.51 116.37,88.26 117,88.26 117.18,88.44 117.2,88.44 117.2,88.44 118.69,88.44 v1(119.24,88.99)
  IN3 w0.117: v1(60.05,95.48) 59.72,95.16 59.72,93.95 59.84,93.83 60.11,93.83 60.22,93.95 60.22,94.18 60.34,94.29 60.58,94.29 60.69,94.18 60.69,93.95 60.81,93.83 86.2,93.83 87.23,94.85 105.83,94.85 108.3,92.39
  BOTTOM w0.089: UC1.H28 v1(119.24,88.99)
  BOTTOM w0.112: JDIMM2.58 59.78,95.74 v1(60.05,95.48)
DDR_B_D20: length 66.2
  IN3 w0.089: 115.35,93.79 115.35,92.9 115.99,92.25 116.5,92.25 117.45,91.31 117.45,91.31 118.49,90.26 118.75,90.26 118.76,90.26 118.88,90.26 v1(119.24,89.9)
  IN3 w0.117: v1(60.05,98.15) 60.78,98.88 107.46,98.88 110.27,96.07 113.06,96.07 115.35,93.79
  BOTTOM w0.089: UC1.G28 v1(119.24,89.9)
  BOTTOM w0.112: JDIMM2.50 59.64,97.74 v1(60.05,98.15)
DDR_B_D21: length 67.5
  IN3 w0.089: v1(118.6,89.9) 117.38,91.13 117.23,91.13 116.36,92 115.87,92 115.09,92.77 115.09,93.52
  IN3 w0.117: v1(64.62,98.15) 65.03,98.56 70.56,98.56 70.68,98.44 70.68,98.05 70.8,97.93 71.03,97.93 71.15,98.05 71.15,98.44 71.26,98.56 71.51,98.56 71.63,98.44 71.63,98.05 71.74,97.93 71.98,97.93 72.1,98.05 72.1,98.44 72.21,98.56 77.92,98.56 78.03,98.44 78.03,98.05 78.15,97.93 78.38,97.93 78.5,98.05 78.5,98.44 78.62,98.56 78.85,98.56 78.97,98.44 78.97,98.05 79.08,97.93 79.32,97.93 79.43,98.05 79.43,98.44 79.55,98.56 81.14,98.56 81.26,98.44 81.26,98.05 81.37,97.93 81.61,97.93 81.72,98.05 81.72,98.44 81.84,98.56 82.07,98.56 82.19,98.44 82.19,98.05 82.31,97.93 82.54,97.93 82.66,98.05 82.66,98.44 82.78,98.56 83.04,98.56 83.16,98.44 83.16,98.05 83.28,97.93 83.51,97.93 83.63,98.05 83.63,98.44 83.75,98.56 107.15,98.56 110.04,95.67 112.95,95.67 115.09,93.52
  BOTTOM w0.089: UC1.G29 v1(118.6,89.9)
  BOTTOM w0.112: JDIMM2.49 64.77,97.99 v1(64.62,98.15)
DDR_B_D22: length 67.9
  IN3 w0.089: v1(117.33,88.99) 117.16,88.82 117.03,88.82 116.84,88.63 116.52,88.63 116.23,88.92 115.51,88.92 112.37,92.07 112.37,93.29 112.05,93.61 107.98,93.61
  IN3 w0.117: v1(63.09,95.48) 62.9,95.28 62.9,94.61 63.04,94.47 63.43,94.47 63.55,94.59 63.55,94.97 63.66,95.09 63.9,95.09 64.01,94.97 64.01,94.59 64.13,94.47 64.38,94.47 64.49,94.59 64.49,94.95 64.61,95.06 64.85,95.06 64.96,94.95 64.96,94.59 65.08,94.47 65.31,94.47 65.43,94.59 65.43,95.04 65.55,95.16 65.78,95.16 65.9,95.04 65.9,94.59 66.01,94.47 66.3,94.47 66.41,94.59 66.41,95.04 66.53,95.16 66.76,95.16 66.88,95.04 66.88,94.59 67,94.47 85.94,94.47 86.96,95.49 106.1,95.49 107.98,93.61
  BOTTOM w0.089: UC1.H31 v1(117.33,88.99)
  BOTTOM w0.112: v1(63.09,95.48) 64.08,94.49 JDIMM2.63
DDR_B_D23: length 68.9
  IN3 w0.089: v1(116.69,88.99) 116.58,89.1 115.65,89.1 115.57,89.18 115.57,89.18 114.23,90.52 112.62,92.13 112.62,93.28 112.52,93.38 112.52,93.39 112.12,93.79 108.26,93.79 108.13,93.91
  IN3 w0.117: 108.13,93.91 106.23,95.81 86.83,95.81 85.8,94.79 81.42,94.79 81.31,94.91 81.31,95 81.19,95.12 80.96,95.12 80.84,95 80.84,94.91 80.72,94.79 80.19,94.79 80.07,94.91 80.07,95.43 79.95,95.55 79.72,95.55 79.6,95.43 79.6,94.91 79.48,94.79 79.24,94.79 79.12,94.91 79.12,95.38 79.01,95.5 78.77,95.5 78.66,95.38 78.66,94.91 78.54,94.79 78.31,94.79 78.19,94.91 78.19,95.38 78.07,95.5 77.84,95.5 77.72,95.38 77.72,94.91 77.6,94.79 77.24,94.79 77.13,94.91 77.13,94.95 77.01,95.06 76.78,95.06 76.66,94.95 76.66,94.91 76.54,94.79 76.31,94.79 76.19,94.91 76.19,94.95 76.08,95.06 75.84,95.06 75.72,94.95 75.72,94.91 75.61,94.79 75.37,94.79 75.26,94.91 75.26,94.95 75.14,95.06 74.91,95.06 74.79,94.95 74.79,94.91 74.67,94.79 74.44,94.79 74.32,94.91 74.32,94.95 74.21,95.06 73.97,95.06 73.86,94.95 73.86,94.91 73.74,94.79 73.5,94.79 73.39,94.91 73.39,94.95 73.27,95.06 73.04,95.06 72.92,94.95 72.92,94.91 72.8,94.79 72.45,94.79 72.33,94.91 72.33,95.43 72.22,95.55 71.98,95.55 71.87,95.43 71.87,94.91 71.75,94.79 71.52,94.79 71.4,94.91 71.4,95.43 71.28,95.55 71.05,95.55 70.93,95.43 70.93,94.91 70.82,94.79 70.58,94.79 70.47,94.91 70.47,95.43 70.35,95.55 70.11,95.55 70,95.43 70,94.91 69.88,94.79 68.83,94.79 68.71,94.91 68.71,95.43 68.59,95.55 68.36,95.55 68.24,95.43 68.24,94.91 68.12,94.79 67.59,94.79 66.9,95.48 v1(64.62,95.48)
  BOTTOM w0.102: v1(116.69,88.99) 116.91,88.77 UC1.H32
  BOTTOM w0.112: JDIMM2.59 64.63,95.49 v1(64.62,95.48)
DDR_B_D24: length 68.7
  IN3 w0.089: 107.69,91.03 111.01,91.03 114.17,87.87 115.84,87.87 116.03,87.69 116.68,87.69 117.2,87.17 v1(117.33,87.17)
  IN3 w0.117: 107.69,91.03 105.24,93.48 87.5,93.48 86.04,92.02 85.47,92.02 85.36,91.9 85.36,91.38 85.24,91.26 85.01,91.26 84.89,91.38 84.89,91.9 84.77,92.02 84.54,92.02 84.42,91.9 84.42,91.38 84.3,91.26 84.07,91.26 83.95,91.38 83.95,91.9 83.84,92.02 83.6,92.02 83.49,91.9 83.49,91.38 83.37,91.26 83.14,91.26 83.02,91.38 83.02,91.9 82.9,92.02 82.67,92.02 82.55,91.9 82.55,91.38 82.44,91.26 82.2,91.26 82.08,91.38 82.08,91.9 81.97,92.02 71.97,92.02 71.86,91.9 71.86,91.38 71.74,91.26 71.51,91.26 71.39,91.38 71.39,91.9 71.27,92.02 71.04,92.02 70.92,91.9 70.92,91.38 70.81,91.26 70.57,91.26 70.46,91.38 70.46,91.9 70.34,92.02 67.09,92.02 66.97,92.13 66.97,92.55 66.86,92.67 66.62,92.67 66.51,92.55 66.51,92.13 66.39,92.02 66.15,92.02 66.04,92.13 66.04,92.55 65.92,92.67 65.69,92.67 65.57,92.55 65.57,92.13 65.45,92.02 64.48,92.02 64.36,92.13 64.36,92.45 64.48,92.57 v1(64.62,92.57)
  BOTTOM w0.102: UC1.L31 v1(117.33,87.17)
  BOTTOM w0.112: JDIMM2.71 65.39,92.49 65.31,92.57 v1(64.62,92.57)
DDR_B_D25: length 70
  IN3 w0.089: v1(116.67,87.17) 116.24,87.17 115.77,87.64 114.13,87.64 111.6,90.17 108.24,90.17
  IN3 w0.117: 108.24,90.17 107.67,90.74 107.53,90.74 105.2,93.07 87.54,93.07 85.41,90.94 81.97,90.94 81.21,91.7 79.29,91.7 79.17,91.58 79.17,91.3 79.05,91.18 78.82,91.18 78.7,91.3 78.7,91.58 78.59,91.7 78.35,91.7 78.24,91.58 78.24,91.11 78.12,90.99 77.89,90.99 77.77,91.11 77.77,91.58 77.65,91.7 77.36,91.7 77.24,91.58 77.24,91.11 77.13,90.99 76.89,90.99 76.78,91.11 76.78,91.58 76.66,91.7 76.43,91.7 76.31,91.58 76.31,91.11 76.19,90.99 75.96,90.99 75.84,91.11 75.84,91.58 75.72,91.7 72.78,91.7 72.66,91.58 72.66,91.06 72.54,90.94 70.14,90.94 70.02,91.06 70.02,91.58 69.9,91.7 68.97,91.7 68.85,91.58 68.85,91.11 68.73,90.99 68.5,90.99 68.38,91.11 68.38,91.58 68.27,91.7 62.44,91.7 v1(61.57,92.57)
  BOTTOM w0.102: UC1.L32 116.7,87.15 v1(116.67,87.17)
  BOTTOM w0.112: v1(61.57,92.57) 60.4,93.74 JDIMM2.66
DDR_B_D26: length 67.7
  IN3 w0.089: 105.58,89.9 105.88,89.61 105.88,89.54 107.39,88.03 107.48,87.82 107.78,87.51 111.42,87.51 113.24,85.69 116.92,85.69 117.13,85.89 118.12,85.89 118.12,85.9 118.23,85.9 118.59,86.26 v1(118.6,86.26)
  IN3 w0.117: 105.58,89.9 104.8,90.68 87.83,90.68 85.41,88.25 84.83,88.25 84.72,88.37 84.72,88.84 84.6,88.96 84.36,88.96 84.25,88.84 84.25,88.37 84.13,88.25 62.02,88.25 61.87,88.4 61.87,88.76 62,88.88 63.03,88.88 63.11,88.96 63.11,89.26 v1(63.09,89.27)
  BOTTOM w0.089: UC1.N29 v1(118.6,86.26)
  BOTTOM w0.112: JDIMM2.79 64.31,90.49 v1(63.09,89.27)
DDR_B_D27: length 67.5
  IN3 w0.089: v1(119.24,86.26) 118.83,85.85 118.53,85.85 118.39,85.72 117.2,85.72 116.95,85.47 113.21,85.47 113.16,85.51 113.14,85.51 111.35,87.3 107.67,87.3 106.21,88.77 106.21,88.96 105.73,89.43 105.57,89.43
  IN3 w0.117: 105.57,89.43 105.54,89.43 104.68,90.29 87.9,90.29 85.54,87.93 61.48,87.93 61.36,88.05 61.36,88.65 61.24,88.77 61.01,88.77 60.89,88.65 60.89,88.05 60.78,87.93 60.31,87.93 60.04,88.2 60.04,89.27 v1(60.05,89.27)
  BOTTOM w0.089: UC1.N28 v1(119.24,86.26)
  BOTTOM w0.112: v1(60.05,89.27) 60.01,89.24 JDIMM2.84
DDR_B_D28: length 65.3
  IN3 w0.089: v1(119.24,87.17) 118.69,87.71 117.16,87.71 116.79,88.08 116.14,88.08 115.92,88.3 115.31,88.3 112.1,91.51 108.31,91.51 107.69,92.14
  IN3 w0.117: 107.69,92.14 105.5,94.33 87.44,94.33 86.42,93.31 60.78,93.31 v1(60.05,92.57)
  BOTTOM w0.102: UC1.L28 v1(119.24,87.17)
  BOTTOM w0.112: JDIMM2.70 59.88,92.74 v1(60.05,92.57)
DDR_B_D29: length 66.9
  IN3 w0.089: 107.94,91.29 111.94,91.29 115.11,88.12 115.85,88.12 116.09,87.88 116.74,87.88 117.09,87.53 118.24,87.53 v1(118.6,87.17)
  IN3 w0.117: v1(63.09,92.57) 63.51,92.99 68.11,92.99 68.23,92.87 68.23,92.5 68.35,92.39 68.58,92.39 68.7,92.5 68.7,92.87 68.81,92.99 69.9,92.99 70.02,92.87 70.02,92.45 70.14,92.34 70.37,92.34 70.49,92.45 70.49,92.87 70.6,92.99 70.84,92.99 70.95,92.87 70.95,92.45 71.07,92.34 71.3,92.34 71.42,92.45 71.42,92.87 71.54,92.99 77.62,92.99 77.73,92.87 77.73,92.57 77.85,92.45 78.08,92.45 78.2,92.57 78.2,92.87 78.32,92.99 86.55,92.99 87.46,93.89 105.33,93.89 107.94,91.29
  BOTTOM w0.102: UC1.L29 v1(118.6,87.17)
  BOTTOM w0.112: JDIMM2.67 64.01,93.49 v1(63.09,92.57)
DDR_B_D30: length 67.7
  IN3 w0.089: 105.57,90.37 107.37,88.57 111.18,88.57 111.77,87.97 111.77,87.43 113.31,85.89 116.83,85.89 117.19,86.26 v1(117.33,86.26)
  IN3 w0.117: v1(64.62,89.27) 64.41,89.06 64.41,88.66 64.49,88.57 65.02,88.57 65.14,88.69 65.14,89.25 65.26,89.36 65.49,89.36 65.61,89.25 65.61,88.69 65.72,88.57 65.96,88.57 66.07,88.69 66.07,89.25 66.19,89.36 66.43,89.36 66.54,89.25 66.54,88.69 66.66,88.57 66.98,88.57 67.1,88.69 67.1,89.25 67.22,89.36 67.45,89.36 67.57,89.25 67.57,88.69 67.69,88.57 68.4,88.57 68.52,88.69 68.52,89.25 68.64,89.36 68.87,89.36 68.99,89.25 68.99,88.69 69.11,88.57 70.12,88.57 70.24,88.69 70.24,89.25 70.36,89.36 70.59,89.36 70.71,89.25 70.71,88.69 70.82,88.57 71.06,88.57 71.17,88.69 71.17,89.25 71.29,89.36 71.52,89.36 71.64,89.25 71.64,88.69 71.76,88.57 83.53,88.57 84.32,89.36 86.07,89.36 87.92,91.22 104.72,91.22 105.57,90.37
  BOTTOM w0.089: UC1.N31 v1(117.33,86.26)
  BOTTOM w0.112: JDIMM2.83 64.84,89.49 v1(64.62,89.27)
DDR_B_D31: length 69.4
  IN3 w0.089: 105.57,90.82 107.54,88.85 111.25,88.85 112.01,88.09 112.01,87.46 113.21,86.25 v1(116.68,86.25)
  IN3 w0.117: v1(61.57,89.27) 61.98,89.68 77.8,89.68 77.92,89.57 77.92,89.01 78.04,88.89 78.27,88.89 78.39,89.01 78.39,89.57 78.5,89.68 78.74,89.68 78.85,89.57 78.85,89.01 78.97,88.89 79.2,88.89 79.32,89.01 79.32,89.57 79.44,89.68 80.87,89.68 80.99,89.57 80.99,89.01 81.11,88.9 81.34,88.9 81.46,89.01 81.46,89.57 81.58,89.68 81.81,89.68 81.93,89.57 81.93,89.01 82.04,88.9 82.28,88.9 82.39,89.01 82.39,89.57 82.51,89.68 82.78,89.68 82.9,89.57 82.9,89.01 83.02,88.89 83.25,88.89 83.37,89.01 83.37,89.57 83.48,89.68 85.93,89.68 87.85,91.6 104.79,91.6 105.57,90.82
  BOTTOM w0.102: v1(116.68,86.25) 116.68,86.24 116.68,86.23 116.73,86.19 UC1.N32
  BOTTOM w0.112: JDIMM2.80 60.6,90.24 v1(61.57,89.27)
DDR_B_D32: length 67.6
  IN3 w0.089: 105.09,72.58 105.74,73.23 113.06,73.23 115.29,75.46 115.87,75.46 116.24,75.84 118.2,75.84 v1(118.6,76.23)
  IN3 w0.117: 105.09,72.58 101.2,72.58 95.41,66.78 89.72,66.78 88.1,65.17 85.02,65.17 83.39,63.55 78.25,63.55 77.62,62.92 65.18,62.92 64.21,63.89 61.05,63.89 v1(59.99,64.95)
  BOTTOM w0.089: UC1.AJ29 118.8,75.89 v1(118.6,76.23)
  BOTTOM w0.102: v1(59.99,64.95) 59.2,65.74 JDIMM2.170
DDR_B_D33: length 67.8
  IN3 w0.089: v1(117.97,76.23) 117.58,76.62 117.19,76.62 117.02,76.79 116.38,76.79 115.58,76 113.79,76 112.38,74.58 109.75,74.58 109.31,74.14 105.33,74.14
  IN3 w0.117: v1(64.61,64.95) 65.2,64.95 65.32,64.83 65.32,64.37 65.44,64.26 65.67,64.26 65.79,64.37 65.79,64.83 65.9,64.95 66.14,64.95 66.25,64.83 66.25,64.37 66.37,64.26 66.6,64.26 66.72,64.37 66.72,64.83 66.84,64.95 67.48,64.95 67.92,64.51 68.33,64.51 68.44,64.62 68.44,64.83 68.56,64.95 68.79,64.95 68.91,64.83 68.91,64.62 69.03,64.51 70.05,64.51 70.16,64.39 70.16,64.02 70.28,63.9 70.51,63.9 70.63,64.02 70.63,64.83 70.75,64.95 70.98,64.95 71.1,64.83 71.1,64.03 71.22,63.91 71.45,63.91 71.57,64.03 71.57,64.39 71.68,64.51 73.2,64.51 73.31,64.39 73.31,63.99 73.43,63.88 73.66,63.88 73.78,63.99 73.78,64.39 73.9,64.51 83,64.51 84.62,66.13 87.71,66.13 89.32,67.74 95.01,67.74 100.6,73.34 104.53,73.34 105.33,74.14
  BOTTOM w0.089: v1(117.97,76.23) 118.15,75.89 UC1.AJ30
  BOTTOM w0.112: v1(64.61,64.95) 64.66,64.99 JDIMM2.173
DDR_B_D34: length 68
  IN3 w0.089: 102.16,71.5 105.78,71.5 106.35,72.07 113,72.07 115.42,74.48 116.54,74.48 v1(116.61,74.41)
  IN3 w0.117: 102.16,71.5 96.19,65.53 90.24,65.53 88.63,63.92 85.54,63.92 83.91,62.29 82.9,62.29 82.79,62.17 82.79,61.9 82.67,61.78 82.44,61.78 82.32,61.9 82.32,62.17 82.2,62.29 81.87,62.29 81.75,62.17 81.75,61.47 81.63,61.35 81.4,61.35 81.28,61.47 81.28,62.17 81.16,62.29 80.93,62.29 80.81,62.17 80.81,61.47 80.7,61.35 80.01,61.35 79.89,61.47 79.89,62.17 79.77,62.29 79.54,62.29 79.42,62.17 79.42,61.47 79.3,61.35 78.99,61.35 78.88,61.47 78.88,61.77 78.76,61.89 78.53,61.89 78.41,61.77 78.41,61.47 78.29,61.35 72.19,61.35 72.07,61.47 72.07,61.54 71.95,61.65 71.72,61.65 71.6,61.54 71.6,61.47 71.48,61.35 71.2,61.35 71.09,61.47 71.09,61.54 70.97,61.66 70.74,61.66 70.62,61.54 70.62,61.47 70.5,61.35 70.27,61.35 70.15,61.47 70.15,61.53 70.04,61.65 69.8,61.65 69.69,61.53 69.69,61.47 69.57,61.35 68.52,61.35 68.4,61.47 68.4,61.54 68.28,61.66 68.05,61.66 67.93,61.54 67.93,61.47 67.81,61.35 67.58,61.35 67.46,61.47 67.46,61.54 67.35,61.66 67.11,61.66 67,61.54 67,61.47 66.88,61.35 66.65,61.35 66.53,61.47 66.53,61.54 66.41,61.66 66.18,61.66 66.06,61.54 66.06,61.47 65.95,61.35 65.71,61.35 65.59,61.47 65.59,61.54 65.48,61.66 65.24,61.66 65.13,61.54 65.13,61.47 65.01,61.35 64.68,61.35 64.56,61.47 v1(64.56,61.64)
  BOTTOM w0.102: UC1.AM32 116.91,74.11 v1(116.61,74.41)
  BOTTOM w0.112: v1(64.56,61.64) 65.41,62.49 JDIMM2.183
DDR_B_D35: length 68.5
  IN3 w0.089: v1(117.28,74.41) 117.13,74.41 116.76,74.04 116.12,74.04 115.71,73.63 114.86,73.63 113.04,71.81 106.52,71.81 106.02,71.31 102.42,71.31
  IN3 w0.117: v1(63.04,61.64) 62.83,61.64 62.49,61.3 62.49,61.15 62.6,61.03 82.04,61.03 82.16,61.15 82.16,61.34 82.27,61.46 82.51,61.46 82.62,61.34 82.62,61.15 82.74,61.03 82.97,61.03 83.09,61.15 83.09,61.8 83.21,61.91 83.44,61.91 83.56,61.8 83.56,61.15 83.67,61.03 83.99,61.03 84.37,61.41 84.37,61.58 84.1,61.85 84.1,62.02 84.76,62.68 84.76,62.68 85.67,63.6 88.76,63.6 90.31,65.15 96.26,65.15 102.42,71.31
  BOTTOM w0.102: UC1.AM31 117.56,74.13 v1(117.28,74.41)
  BOTTOM w0.112: JDIMM2.187 65.54,61.49 65.06,61.01 63.68,61.01 v1(63.04,61.64)
DDR_B_D36: length 69
  IN3 w0.089: v1(117.97,74.41) 117.59,74.04 117.06,74.04 116.75,73.72 116.05,73.72 113.49,71.16 113.01,71.16 112.61,71.57 106.73,71.57 106.27,71.11
  IN3 w0.117: v1(61.52,61.64) 62.44,60.71 84.12,60.71 84.91,61.5 84.91,61.66 84.63,61.94 84.63,62.1 84.8,62.27 84.96,62.27 85.24,61.99 85.4,61.99 85.57,62.16 85.57,62.32 85.29,62.6 85.29,62.76 85.46,62.93 85.62,62.93 85.9,62.65 86.06,62.65 86.69,63.28 88.89,63.28 90.44,64.83 96.39,64.83 102.68,71.11 106.27,71.11
  BOTTOM w0.089: v1(117.97,74.41) 118,74.35 UC1.AM30
  BOTTOM w0.112: JDIMM2.186 59.31,61.74 59.92,61.13 61,61.13 v1(61.52,61.64)
DDR_B_D37: length 69.2
  IN3 w0.089: 103.57,70.78 111.85,70.78 112.06,70.99 113.56,70.99 116.03,73.45 116.1,73.45 116.19,73.54 116.82,73.54 116.93,73.66 117,73.66 117.16,73.82 118.01,73.82 v1(118.6,74.41)
  IN3 w0.117: v1(59.99,61.64) 59.53,61.18 59.53,60.58 59.71,60.39 84.26,60.39 86.82,62.96 89.02,62.96 90.57,64.51 96.52,64.51 102.8,70.78 103.57,70.78
  BOTTOM w0.089: v1(118.6,74.41) 118.63,74.35 UC1.AM29
  BOTTOM w0.112: JDIMM2.182 59.35,62.74 59.99,62.1 v1(59.99,61.64)
DDR_B_D38: length 66.2
  IN3 w0.089: v1(117.33,76.23) 116.94,76.62 116.46,76.62 115.66,75.82 114.05,75.82 111.95,73.72 105.29,73.72
  IN3 w0.117: 105.29,73.72 104.66,73.08 100.8,73.08 95.14,67.42 89.45,67.42 87.84,65.81 84.76,65.81 83.13,64.19 74.58,64.19 73.95,63.56 73.07,63.56 72.47,64.16 72.15,64.16 71.55,63.56 70.17,63.56 69.54,64.19 67.58,64.19 67.46,64.07 67.46,63.74 67.35,63.62 66.32,63.62 66.2,63.74 66.2,63.76 66.08,63.88 65.85,63.88 65.73,63.76 65.73,63.74 65.62,63.62 65.38,63.62 64.47,64.53 63.45,64.53 v1(63.04,64.95)
  BOTTOM w0.089: UC1.AJ31 v1(117.33,76.23)
  BOTTOM w0.112: v1(63.04,64.95) 63.77,65.67 65.16,65.67 65.48,65.99 JDIMM2.169
