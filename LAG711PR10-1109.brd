# Allegro board LAG711PR10-1109.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 46.49,25.37 47.01,25.37 47.28,25.1 47.28,23.86 47.09,23.67 44.96,23.67 44.55,23.62 44.18,23.48 44.17,23.47 43.96,23.34 43.78,23.18 43.33,22.74 39.48,22.74 39.4,22.82 39.4,23.35 39.68,23.63 41.48,23.63 41.57,23.71 41.57,24.17 41.64,24.24 43.52,24.24 43.53,24.24 43.7,24.24 43.77,24.16 44.18,24.16 44.49,24.47 44.49,25.58 44.62,25.71 46.14,25.71
GND on BOTTOM (solid shape): 135.92,148.52 135.92,147.13 135.86,147.06 135.22,147.06 135.1,147.18 135.1,147.92 135.01,148.01 135.01,148.52 134.87,148.65 134.15,148.65 133.32,147.82 132.11,147.82 131.73,147.44 131.73,146.87 131.67,146.81 131.16,146.81 131.1,146.87 131.1,147.38 130.91,147.57 130.21,147.57 130.08,147.44 130.08,147.06 129.88,146.86 129.56,146.86 129.32,146.62 129.32,146.24 129.07,145.98 126.65,145.98 126.53,146.11 126.53,146.49 126.65,146.62 128.11,146.62 128.59,147.09 128.62,147.09 129.6,147.53 130.21,148.14 131.35,148.14 131.61,148.4 132.97,148.4 133.73,149.16 135.29,149.16
GND on BOTTOM (solid shape): 164.91,88.43 164.91,87.74 165.08,87.57 165.08,87.57 166.23,87.57 166.31,87.49 166.31,86.4 166.54,86.17 167.19,86.17 167.28,86.08 167.28,85.96 167.18,85.86 166.47,85.86 166.26,86.07 164.84,86.07 164.76,85.99 164.76,75.18 163.55,73.97 160.12,73.97 159.93,74.16 159.93,78.29 160.56,78.93 160.56,80.94 161.36,81.73 161.36,82.39 161.77,82.8 162.4,82.8 162.56,82.96 162.56,87.51 162.6,87.55 163.84,87.55 163.89,87.5 163.89,87 163.95,86.94 164.47,86.94 164.53,87.01 164.55,87.01 164.55,87.02 164.59,87.07 164.59,87.74 164.55,87.78 164.55,87.85 164.53,87.85 164.53,88.43 164.59,88.5 164.85,88.5
GND on BOTTOM (solid shape): 163.67,66.78 163.67,64.55 163.83,64.39 163.84,64.39 163.91,64.32 169.2,64.32 169.39,64.13 169.39,59.82 168.72,59.15 167.08,59.15 167.08,59.14 164.57,59.14 164.35,58.92 164.35,57.62 164.2,57.46 162.28,57.46 161.83,57.91 161.83,60.83 162.09,61.08 165.71,61.08 165.85,61.22 165.85,62.07 165.64,62.28 162.02,62.28 161.98,62.32 161.98,63.43 162.03,63.48 162.45,63.48 162.52,63.48 162.59,63.54 162.59,64.09 162.43,64.24 161.8,64.24 161.7,64.14 161.02,64.14 160.96,64.2 160.96,64.38 161.04,64.46 161.63,64.46 161.98,64.81 161.98,65.78 162.02,65.83 163.26,65.83 163.26,65.83 163.32,65.89 163.32,65.9 163.36,65.94 163.36,66.78 163.44,66.86 163.6,66.86
GND on BOTTOM (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.94 15.09,22.51 15.09,21.17 14.56,20.64 4.71,20.64 4.71,21.46 4.71,22 4.79,22.21 5,22.29 5.66,22.29 13.5,22.29 14.2,22.88 13.74,23.66 13.71,23.68 13.71,24.54 14.16,24.54
GND on BOTTOM (solid shape): 131.69,92.32 131.69,91.43 132.38,90.75 132.38,90.06 132.25,89.93 132.02,89.93 132.01,89.94 131.9,89.96 131.79,89.94 131.78,89.93 131.72,89.93 131.59,89.81 131.59,87.34 131.51,87.27 131.39,87.27 131.13,87.52 130.93,87.52 130.8,87.65 130.8,87.85 130.88,87.93 130.88,89.53 130.8,89.6 130.8,89.85 130.86,90.02 130.8,90.2 130.8,90.5 130.86,90.67 130.8,90.85 130.8,91.15 130.86,91.32 130.8,91.5 130.8,91.8 130.86,91.97 130.8,92.15 130.8,92.4 130.96,92.55 131.46,92.55
GND on BOTTOM (solid shape): 165.07,112.82 165.16,112.76 165.15,112.65 164.05,109.13 165.65,105.81 165.68,105.74 165.65,105.67 165,105.02 159.84,105.02 157.89,103.06 157.89,101.78 157.21,101.11 157.21,100.87 154.75,100.87 153.34,102.28 153.34,104.31 152.87,104.79 151.16,104.79 151.1,104.84 151.1,107.58 152.01,108.49 157.66,108.49 161.99,112.82
GND on BOTTOM (solid shape): 165.05,109.49 169.09,113.5 171.24,113.5 171.34,112 171.65,107 171.69,106.49 171.75,105.5 169.11,105.5
GND on BOTTOM (solid shape): outline of 83 points within 133.82,98.59 150.99,108.49
GND on BOTTOM (solid shape): 13.78,122.12 13.78,119.47 13.37,119.06 12.35,119.06 10.98,120.43 10.98,121.45 12.2,121.45 12.2,121.39 12.22,121.34 12.24,121.29 12.27,121.24 12.3,121.19 12.31,121.16 12.3,121.13 12.27,121.07 12.24,121.03 12.22,120.98 12.2,120.92 12.2,120.87 12.2,120.82 12.21,120.76 12.23,120.71 12.26,120.67 12.29,120.63 12.33,120.59 12.38,120.56 12.42,120.53 12.48,120.52 12.53,120.51 12.58,120.51 12.64,120.52 12.69,120.53 12.74,120.56 12.78,120.59 12.82,120.63 12.85,120.67 12.88,120.71 12.9,120.76 12.91,120.82 12.91,120.87 12.91,120.92 12.9,120.98 12.87,121.03 12.85,121.07 12.81,121.13 12.81,121.16 12.81,121.19 12.85,121.24 12.87,121.29 12.9,121.34 12.91,121.39 12.91,121.45 12.91,121.5 12.9,121.55 12.88,121.6 12.85,121.65 12.82,121.69 12.78,121.73 12.74,121.76 12.69,121.78 12.64,121.8 12.58,121.81 12.53,121.81 12.48,121.8 12.42,121.78 12.38,121.76 12.33,121.73 12.29,121.69 12.26,121.65 12.23,121.6 12.21,121.55 12.2,121.5 12.2,121.45 10.98,121.45 10.98,122.84 11.06,122.91 12.99,122.91
GND on BOTTOM (solid shape): 97.5,153 97.65,152.65 98,152.5 100,152.5 100.35,152.65 100.5,153 100.5,154.4 103,154.4 103,153.85 98.91,150 95,154.03 95,154.4 97.5,154.4
GND on BOTTOM (solid shape): 159.49,95.58 159.49,94.69 159.29,94.5 159.29,93.47 159.49,93.27 162.6,93.27 162.68,93.2 162.68,92.5 162.78,92.39 167.23,92.39 167.55,92.07 167.55,89.02 167.32,88.79 166.16,88.79 165.71,89.24 165.71,89.26 165.43,89.54 165.06,89.39 165,89.35 164.93,89.35 164.55,89.29 164.46,88.91 164.44,88.82 164.36,88.78 163.38,88.78 163.38,88.78 161.79,88.78 161.43,89.14 161.43,89.47 161.43,89.47 161.43,89.73 161.71,90.01 161.71,90.9 161.61,91 161.61,91.01 161.54,91.07 157.85,91.07 157.79,91.13 157.79,92.28 157.82,92.31 158.52,92.31 158.64,92.43 158.64,92.62 158.35,92.92 158.34,92.93 158.3,92.97 157.01,92.97 156.91,93.07 156.91,93.2 156.97,93.26 157.52,93.26 157.76,93.5 157.76,94.6 157.86,94.7 158.05,94.7 158.18,94.83 158.18,95.48 158.18,95.56 158.27,95.65 158.4,95.65 158.5,95.56 158.5,94.91 158.62,94.78 158.94,94.78 159.17,95.01 159.17,95.57 159.26,95.66 159.41,95.66
GND on BOTTOM (solid shape): 124.27,137.08 124.29,137.05 124.33,137.01 124.36,136.84 124.37,136.78 124.35,136.72 124.35,136.51 124.34,136.43 124.05,136.14 124.04,136.14 123.89,136.05 123.8,135.9 123.79,135.88 121.25,133.34 121.24,133.34 121.09,133.25 121,133.1 120.99,133.08 120.25,132.34 120.24,132.34 120.09,132.25 120,132.1 119.99,132.08 119.66,131.75 119.2,131.75 119.07,131.87 119.07,132.22 119.5,132.65 119.52,132.69 119.53,132.7 119.65,132.82 119.7,132.98 119.7,132.98 119.73,133.06 119.81,133.08 119.82,133.08 119.91,133.08 119.99,133.11 120,133.12 120.07,133.12 120.4,133.45 120.42,133.45 120.55,133.51 120.65,133.62 120.7,133.81 120.63,134 120.63,134.03 120.97,134.37 121.48,134.37 122.81,135.7 122.81,136.2 123.12,136.52 123.15,136.5 123.51,136.49 123.7,136.81 123.7,136.83 123.85,136.99 123.87,136.99 123.94,137.03 124,137.08
GND on BOTTOM (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.03 14.7,44.58 12.63,44.58 11.84,43.79 11.84,37.98 11.99,37.83 14.69,37.83 15.09,37.43 15.09,36.24 14.62,35.78 14.58,35.09 14.16,34.55 14.16,34.19 13.71,34.19 13.71,34.82 13.74,34.84 14.2,35.62 13.5,36.21 5,36.21 4.79,36.29 4.71,36.5 4.71,45.9 4.79,46.11 5,46.19 13.5,46.19 14.2,46.78 13.74,47.56 13.71,47.58 13.71,48.11 14.16,48.11
GND on BOTTOM (solid shape): 125.92,134.85 126.3,134.96 126.19,134.57 126.14,134.56 125.38,133.8 125.27,133.61 125.11,133.57 124.93,133.53 124.85,133.37 124.78,133.24 124.64,133.19 124.56,133.19 124.38,133 124.3,132.84 124.14,132.76 123.53,132.16 123.56,132.06 123.54,131.89 123.4,131.78 123.36,131.77 123.14,131.55 123.12,131.46 123.11,131.43 123.09,131.39 123.09,131.37 122.43,130.71 122.43,130.67 121.92,130.16 121.66,130.16 121.58,130.26 121.47,130.33 121.41,130.4 121.43,130.5 123.18,132.24 123.18,132.27 123.91,133 123.92,133.05 123.98,133.16 124.09,133.22 124.14,133.23 124.47,133.56 124.5,133.56 125.03,134.09 125.2,134.09 125.91,134.8
GND on BOTTOM (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.89,66.75 11.68,65.96 11.68,64.82 15.1,61.4 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on BOTTOM (solid shape): outline of 137 points within 48.05,41.03 53.39,46.75
GND on BOTTOM (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on BOTTOM (solid shape): outline of 171 points within 213.14,40.94 216.44,45.12
GND on BOTTOM (solid shape): outline of 99 points within 120.11,130.77 126.98,137.49
GND on BOTTOM (solid shape): outline of 190 points within 123.91,128.71 127.37,133.23
GND on BOTTOM (solid shape): outline of 222 points within 80.22,122.3 93.53,139.39
GND on BOTTOM (solid shape): outline of 313 points within 213.14,49.84 217.72,56.07
GND on BOTTOM (solid shape): outline of 527 points within 75.15,127.68 82.15,140.88
GND on BOTTOM (solid shape): outline of 1794 points within 0.2,0.2 228.2,155.3
GND on BOTTOM (solid shape): outline of 1868 points within 116.08,75.61 124.25,93.44
GND on BOTTOM (solid shape): outline of 15741 points within 55.46,44.79 98.21,112.69
GND on GND1 (solid shape): 171.34,112 169.05,112 166.55,109.5 169.05,107 171.66,107 171.71,106.12 165.69,106.12 165.69,112.9 171.28,112.9
GND on IN1 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.94 15.09,22.51 15.09,21.17 14.56,20.64 4.71,20.64 4.71,22 4.79,22.21 5,22.29 13.5,22.29 14.2,22.88 13.74,23.66 13.71,23.68 13.71,24.54 14.16,24.54
GND on IN1 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.11 15.15,45.11 15.15,45.02 14.7,44.58 13.19,44.58 13.04,44.43 13.04,37.83 14.69,37.83 15.11,37.41 15.11,36.26 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.72 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN1 (solid shape): 5.39,66.25 5.6,65.75 6.1,65.54 6.9,65.54 7.4,65.75 7.61,66.25 7.61,66.74 10.9,66.74 11.65,65.99 11.65,64.97 11.65,64.97 11.65,64.87 15.09,61.43 15.09,60.35 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.41 13.71,58.41 13.71,58.72 13.74,58.74 14.2,59.52 13.5,60.11 5,60.11 4.79,60.19 4.71,60.4 4.71,64.2 4.5,64.7 4,64.91 0.6,64.91 0.39,64.99 0.31,65.2 0.31,66.45 0.39,66.66 0.6,66.74 5.39,66.74
GND on IN1 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.83,90.46 10.94,90.34 16.51,90.34 16.81,90.04 16.81,89.09 16.65,88.92 15.79,88.92 15.19,88.32 12.94,88.32 12.05,87.42 12.05,84.09 12.05,84.09 12.05,81.87 12.15,81.81 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN1 (solid shape): outline of 191 points within 79.82,126.36 94.09,134.22
GND on IN1 (solid shape): outline of 271 points within 39.5,21.37 56.12,28.81
GND on IN1 (solid shape): outline of 581 points within 0.21,102.63 94.99,154.19
GND on IN1 (solid shape): outline of 253 points within 10.59,0.2 228.2,155.3
GND on IN1 (solid shape): outline of 1369 points within 14.08,88.94 30.52,106.6
GND on IN2 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 14.66,22.87 15.1,22.43 15.1,21.17 14.56,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN2 (solid shape): 89.01,133.12 89.01,131.58 89.45,131.14 89.54,131.14 89.55,131.13 89.73,131.08 89.91,131.14 93.25,131.14 93.72,130.67 93.72,129.19 93.26,128.74 89.14,128.74 88.71,128.3 88.71,126.77 88.3,126.36 84.45,126.36 84.24,126.58 84.24,127.61 84.28,127.62 84.33,127.61 84.76,127.72 84.75,128.16 84.73,128.23 84.75,128.29 84.76,128.74 84.33,128.84 84.28,128.83 84.24,128.85 84.24,131.23 84.29,131.24 84.35,131.22 84.82,131.26 84.84,131.73 84.82,131.8 84.84,131.86 84.82,132.34 84.35,132.37 84.35,133.61 84.57,133.83 88.3,133.83
GND on IN2 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.11 15.15,45.11 15.15,45.02 14.7,44.58 13.19,44.58 13.04,44.43 13.04,37.83 14.69,37.83 15.11,37.41 15.11,36.26 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.72 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN2 (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.87,66.75 11.65,65.96 11.65,64.88 15.12,61.41 15.12,60.37 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on IN2 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.82,90.46 10.92,90.36 13.46,90.36 13.89,89.94 13.89,89.2 13.55,88.86 11.94,88.86 11.76,88.68 11.76,81.98 12.01,81.89 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 8.24,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 3.68,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN2 (solid shape): 172.62,89.5 172.68,89.43 176.43,80.42 183.82,74.04 184.78,73.38 185.55,72.51 185.83,72.11 186.04,71.87 186.31,71.7 192.07,69.01 192.48,68.91 192.91,68.95 193.27,69.05 194.56,69.24 195.85,69.07 206.29,67.7 216.71,69.19 216.72,69.2 226.9,69.2 227.82,68.82 228.2,67.9 228.2,55.03 228.02,53.75 227.51,52.57 225.94,49.94 225.39,48.65 225.2,47.27 225.2,23.95 225.11,23.74 224.9,23.65 213.6,23.65 213.39,23.74 213.3,23.95 213.3,27.53 213.59,27.81 213.7,27.83 213.76,27.74 213.76,24.11 224.74,24.11 224.74,47.27 224.94,48.78 225.54,50.18 227.12,52.8 227.58,53.88 227.74,55.03 227.74,67.9 227.49,68.49 226.9,68.74 216.79,68.74 206.26,67.24 195.73,68.62 194.56,68.78 193.39,68.61 193.03,68.51 192.44,68.45 191.87,68.6 186.11,71.28 185.74,71.52 185.45,71.85 185.17,72.25 184.47,73.03 183.6,73.63 176.05,80.15 172.22,89.36 172.33,89.47 172.35,89.47 172.44,89.47 172.53,89.5
GND on IN2 (solid shape): outline of 580 points within 0.2,102.63 94.99,154.19
GND on IN2 (solid shape): outline of 15632 points within 10.6,0.21 228.19,155.3
GND on IN3 (solid shape): 224.06,34.06 224.11,34.09 224.18,34.08 225.2,34.08 225.2,23.95 225.11,23.74 224.9,23.65 213.6,23.65 213.39,23.74 213.3,23.95 213.3,28.35 213.25,28.63 213.08,28.86 213.27,29.05 214.88,29.05 214.9,29.04 218.25,29.04 218.25,29.04 218.31,29.04 218.32,29.05 219.94,29.05 222.55,31.66 222.55,31.76 222.57,31.78 222.57,32.58
GND on IN3 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.51,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN3 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.11 15.15,45.11 15.15,45.02 14.7,44.58 13.19,44.58 13.04,44.43 13.04,37.83 14.69,37.83 15.11,37.41 15.11,36.26 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.72 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN3 (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.89,66.75 11.65,65.99 11.65,64.88 15.1,61.44 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on IN3 (solid shape): 10.71,90.66 10.71,90.66 10.71,90.55 10.93,90.36 11.09,90.11 13.37,90.11 13.76,89.72 13.76,89.26 11.69,87.2 11.69,82.02 11.73,81.99 12,81.9 12.24,81.74 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.21,79.2 12.21,80.85 12,81.35 11.5,81.56 7.61,81.56 7.61,82.05 7.4,82.55 6.9,82.76 6.1,82.76 5.6,82.55 5.39,82.05 5.39,81.56 0.6,81.56 0.39,81.64 0.31,81.85 0.31,83.35 0.39,83.56 0.6,83.64 2,83.64 2.5,83.85 2.71,84.35 2.71,88.6 2.79,88.81 3,88.89 10.05,88.89 10.74,89.48 10.29,90.26 10.26,90.28 10.26,91.4 10.71,91.4
GND on IN3 (solid shape): outline of 514 points within 0.21,102.63 94.99,154.19
GND on IN3 (solid shape): outline of 263 points within 10.59,0.2 228.2,155.3
GND on GND2 (solid shape): 171.34,112 169.05,112 166.55,109.5 169.05,107 171.66,107 171.72,106.07 165.56,106.07 165.56,112.72 171.29,112.72
GND on GND1: outline of 476 points within 0.2,0.2 228.2,155.3
GND on VCC: 60.21,44.51 56.64,48.08 56.64,70.53 57.82,71.71 57.82,72.81 56.64,73.98 56.64,109.03 59.94,112.33 90.73,112.33 95.31,107.75 119.82,107.75 123.35,104.22 123.35,94.27 119.67,90.59 119.67,77 119.03,76.36 119.03,63.03 118.48,62.48 116.39,62.48 113.83,59.92 113.83,49.72 100,49.72 99.37,49.08 94.42,49.08 89.84,44.51
GND on VCC: 20.74,78.29 19.97,79.05 16.03,79.05 15.21,79.88 12.2,79.88 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.75,89.5 10.25,90.27 10.25,103.43 10.75,104.2 10.05,104.8 2,104.8 1.79,104.89 1.7,105.1 1.7,107.3 1.79,107.51 2,107.6 3.35,107.6 3.85,107.8 4.05,108.3 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,126.6 0.29,126.81 0.5,126.9 1.05,126.9 1.55,127.1 1.75,127.6 1.75,133.6 1.84,133.81 2.05,133.9 13.75,133.9 13.75,107.52 18.88,102.39 18.88,89.55 16.13,86.8 16.13,85.53 20.74,80.93
GND on VCC: 176.87,78.3 179.88,75.44 183.37,73.18 183.71,72.98 184.03,72.75 184.42,72.38 184.76,71.96 185.03,71.56 185.42,71.14 185.9,70.83 191.66,68.14 191.8,68.08 191.94,68.03 192.55,67.94 193.17,68.02 193.53,68.12 193.85,68.2 194.17,68.25 194.42,68.27 194.67,68.27 194.82,68.26 195.07,68.24 195.31,68.2 189.53,62.42 185.88,62.42 185.88,62.42 181.91,62.42 181.9,62.43 181.9,66.41 170.62,77.68 170.62,78.29 170.63,78.3
GND on VCC: 11,0.2 10.79,0.29 10.7,0.5 10.7,4.6 10.65,4.86 10.5,5.09 11.19,5.77 14.62,5.77 17.28,8.44 22.03,8.44 23.17,7.3 27.11,7.3 27.61,6.79 29.6,6.79 30.64,7.83 30.64,8.04 30.51,8.17 30.51,9.28 31.02,9.79 31.02,11.21 30.87,11.36 29.65,11.36 27.74,9.46 24.02,9.46 23.78,9.69 23.78,11.56 24.09,11.87 25.36,11.87 25.99,12.5 29.86,12.5 30.01,12.65 30.01,14.56 30.11,14.66 33.67,14.66 34.45,15.45 34.45,20.4 34.68,20.63 41,20.63 41,4.1 40.91,3.89 40.7,3.8 36.6,3.8 36.1,3.6 35.9,3.1 35.9,0.5 35.81,0.29 35.6,0.2
GND on VCC: 16.14,18.73 15,19.87 4.7,19.87 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.2,22.9 13.7,23.67 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,58.73 14.2,59.5 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 11.5,66.75 11.75,66.79 11.97,66.93 11.97,65.66 15.47,62.16 20.74,62.16 20.74,24.34 22.77,22.31 22.77,20.48 22.03,19.74 18.34,19.74 17.33,18.73
GND on VCC: 173.24,53.65 173.14,53.76 173.14,58.12 173.24,58.22 177.6,58.22 177.71,58.12 177.71,53.76 177.6,53.65
GND on VCC: 106.46,145.6 106.46,147.65 108.6,149.79 119.18,149.79 121.85,147.12 125.99,147.12 125.99,145.6
GND on IN2: outline of 131 points within 56.42,44.38 125.37,110.61
GND on GND2: outline of 289 points within 0.2,0.2 228.2,155.3
VCCGT_B+ on TOP (solid shape): 165.26,95.94 165.26,92.71 165.07,92.51 162.72,92.51 162.53,92.71 162.53,94.74 161.45,95.82 161.45,96.58 162.86,97.99 163.22,97.99
VCCGT_B+ on BOTTOM (solid shape): 160.09,100.81 160.64,100.81 160.64,101.37 160.89,101.37 160.89,100.81 161.44,100.81 161.44,101.37 162.01,101.37 164.08,99.31 166.95,99.31 167.41,98.84 167.41,94.7 168.28,93.83 168.28,92.95 168.69,92.54 168.69,89.97 168.5,89.78 167.86,89.78 167.74,89.91 167.74,92.13 167.36,92.51 162.91,92.51 162.84,92.59 162.84,93.26 162.66,93.44 159.66,93.44 159.62,93.48 159.62,94.6 159.68,94.66 160.93,94.66 161.17,94.9 161.17,95.49 161.17,95.49 161.17,95.57 161.29,95.69 161.87,95.69 161.9,95.73 161.99,95.73 162.23,95.97 162.23,96.07 162.24,96.12 162.23,96.17 162.23,96.26 162.05,96.44 162.05,98.21 161.67,98.59 159.42,98.59 159.22,98.79 159.14,98.96 158.98,99.04 158.94,99.07 158.94,100.9 159.03,100.99 159.04,100.99 159.42,101.37 160.09,101.37
VCCSA_B+ on TOP (solid shape): 169.71,58.48 169.71,57.84 169.45,57.59 167.75,57.59 165.9,55.74 165.9,54.97 165.64,54.72 165.64,53.78 165.58,53.72 164.56,53.72 164.44,53.84 164.44,54.67 163.49,55.62 163.49,57.91 164.16,58.58 169.6,58.58
VCCSA_B+ on BOTTOM (solid shape): 166.42,58.67 166.42,56.37 166.55,56.24 166.99,56.24 167.11,56.12 167.11,54.8 166.91,54.61 165.77,54.61 165.58,54.41 165.58,53.76 165.53,53.72 164.56,53.72 163.91,54.37 161.27,54.37 161.27,54.88 161.79,54.88 161.91,55 161.91,56.2 161.57,56.55 160.82,56.55 160.74,56.63 160.74,57.13 160.8,57.19 164.29,57.19 164.29,57.25 164.63,57.59 164.63,58.85 164.67,58.88 166.21,58.88
VDD10 on TOP (solid shape): 22.3,87.92 22.3,87.1 22.3,87.1 22.3,86.4 22.17,86.27 21.11,86.27 20.99,86.38 20.99,87.14 20.71,87.42 20.71,88 20.77,88.05 22.16,88.05
VDD10 on BOTTOM (solid shape): 21.85,82.33 21.85,82.25 21.85,80.82 21.74,80.71 21.2,80.71 21.1,80.61 20.55,80.61 20.35,80.8 20.35,82.14 20.63,82.42 21.76,82.42
VDD10 on BOTTOM (solid shape): 27.47,79.1 27.47,78.59 26.95,78.08 26.74,78.14 26.53,78.06 23.61,78.06 23.36,78.32 23.36,79.04 23.53,79.22 27.35,79.22
VDD10 on IN1 (solid shape): 22.78,81.35 22.77,81.31 22.83,80.89 23.25,80.83 23.28,80.85 23.88,80.26 23.88,78.83 23.58,78.53 22.29,78.53 22.04,78.78 22.04,79.47 21.52,79.99 21.04,79.99 20.65,80.37 20.65,81.58 20.8,81.73 22.4,81.73
VDD10 on IN3 (solid shape): 22.32,81.82 22.32,81.54 21.39,80.61 20.61,80.61 20.48,80.74 20.48,81.33 21.48,82.33 21.81,82.33
VDD10 on IN3 (solid shape): 22.35,87.98 23.97,86.36 23.97,85.59 23.74,85.36 23.74,84.39 23.64,84.29 21.32,84.29 20.63,84.98 20.63,85.1 22.61,85.1 22.62,85.04 22.63,84.99 22.64,84.94 22.67,84.89 22.7,84.85 22.74,84.81 22.78,84.78 22.83,84.76 22.88,84.74 22.94,84.73 22.99,84.73 23.04,84.74 23.09,84.75 23.14,84.77 23.19,84.8 23.23,84.84 23.26,84.88 23.29,84.93 23.31,84.98 23.32,85.03 23.33,85.08 23.32,85.14 23.31,85.19 23.29,85.24 23.27,85.29 23.23,85.34 23.23,85.37 23.23,85.4 23.27,85.46 23.3,85.5 23.32,85.55 23.33,85.6 23.34,85.66 23.34,85.71 23.33,85.76 23.31,85.81 23.28,85.86 23.25,85.9 23.21,85.94 23.17,85.97 23.12,86 23.07,86.02 23.02,86.02 22.96,86.03 22.91,86.02 22.86,86 22.81,85.98 22.76,85.95 22.72,85.92 22.69,85.87 22.66,85.83 22.64,85.78 22.63,85.73 22.63,85.67 22.63,85.62 22.64,85.57 22.66,85.52 22.69,85.47 22.72,85.41 22.73,85.38 22.72,85.36 22.68,85.3 22.65,85.25 22.63,85.2 22.62,85.15 22.61,85.1 20.63,85.1 20.63,87.73 20.88,87.98 21.92,87.98
VDD_1.2V on TOP (solid shape): 36.15,27.64 36.15,26.82 35.14,25.81 33.68,25.81 33.68,25.8 33.5,25.8 33.36,25.67 33.36,25.01 33.33,24.98 31.36,24.98 31.29,25.05 31.29,25.89 31.64,26.23 33.97,26.23 35.45,27.72 36.07,27.72
VDDP_1.2V on TOP (solid shape): 36.55,27.65 36.55,26.39 37.32,25.63 37.32,25 37.3,24.98 33.53,24.98 33.5,25.01 33.5,25.62 33.52,25.65 35.21,25.65 36.34,26.78 36.34,27.64 36.41,27.71 36.49,27.71
VDDREG on TOP (solid shape): 23.38,85.81 23.38,84.87 23.3,84.79 23.3,83.96 23.25,83.91 23.14,83.91 23.09,83.97 23.09,84.72 22.93,84.88 22.8,84.88 22.76,84.88 22.65,84.99 22.65,85.82 22.72,85.9 23.19,85.9 23.29,85.9
VDDREG on BOTTOM (solid shape): 23.21,85.83 23.21,84.54 23.13,84.46 22.35,84.46 22.23,84.33 22.18,84.33 21.96,84.11 21.96,83.57 21.85,83.47 21.35,83.47 21.28,83.54 21.28,84.23 21.57,84.51 21.89,84.51 21.92,84.55 21.92,85.49 21.98,85.56 22.65,85.56 22.76,85.67 22.76,85.79 22.87,85.9 23.14,85.9
+BIF_VDDC on TOP (solid shape): 125.35,137.72 125.35,136.98 125.27,136.9 123.1,136.9 122.97,137.03 122.97,137.74 123.1,137.86 125.2,137.86
+BIF_VDDC on TOP (solid shape): 122.45,143.31 123.17,143.31 123.9,142.58 123.9,142.12 123.9,142.06 123.54,141.71 121.89,141.71 121.65,141.96 121.67,141.99 121.67,142.36 121.34,142.53 121.32,142.53 121.32,143.71 121.36,143.75 122.02,143.75
+BIF_VDDC on IN3 (solid shape): outline of 396 points within 121.61,136.88 126.19,142.89
+CCG_VBUS on TOP (solid shape): 10.7,122.87 10.7,122.3 10.64,122.23 8.23,122.23 8.16,122.3 8.16,122.68 8.29,122.8 9.18,122.8 9.31,122.93 10.64,122.93
+CCG_VBUS on TOP (solid shape): 10.7,120.07 10.7,119.57 10.64,119.5 9,119.5 8.99,119.51 8.26,119.51 8.24,119.52 7.95,119.52 7.82,119.66 6.97,119.66 6.81,119.66 6.66,119.75 6.48,119.74 6.47,119.75 6.47,120.01 6.51,120.04 6.59,120.04 6.67,120.05 6.83,120.05 6.87,120 7.77,120 7.91,120.14 10.64,120.14
+CCG_VBUS on BOTTOM (solid shape): 33.31,122.99 33.31,120.07 32.99,119.76 31.04,119.76 30.72,119.44 30.72,118.59 30.61,118.49 29.92,118.49 29.81,118.59 29.81,120.55 28.86,121.5 28.86,123.06 29.18,123.38 32.93,123.38
+CCG_VBUS on BOTTOM (solid shape): 10.79,122.87 10.79,120.33 12.35,118.76 12.35,116.52 12.1,116.26 10.45,116.26 10.19,116.52 10.19,118.15 9.66,118.68 8.74,118.68 7.4,120.01 7.4,121.9 7.98,121.9 7.98,121.85 7.99,121.8 8.01,121.75 8.03,121.7 8.06,121.65 8.1,121.62 8.14,121.58 8.19,121.56 8.23,121.54 8.29,121.52 8.34,121.52 8.39,121.52 8.44,121.54 8.49,121.56 8.54,121.58 8.58,121.62 8.62,121.65 8.65,121.7 8.67,121.75 8.69,121.8 8.7,121.85 8.7,121.9 8.69,121.96 8.67,122.01 8.65,122.06 8.62,122.1 8.58,122.14 8.54,122.17 8.49,122.2 8.44,122.22 8.39,122.23 8.34,122.23 8.29,122.23 8.23,122.22 8.19,122.2 8.14,122.17 8.1,122.14 8.06,122.1 8.03,122.06 8.01,122.01 7.99,121.96 7.98,121.9 7.4,121.9 7.4,122.87 7.54,123 10.66,123
+CCG_VBUS on IN2: 34.33,129.65 34.33,120.37 33.22,119.26 28.7,119.26 28.31,119.65 28.31,125.41 25.92,127.8 18.37,127.8 16.83,126.27 16.83,119.91 15.6,118.68 8.67,118.68 8.09,119.25 8.09,122.85 8.67,123.42 8.67,123.59 8.72,123.78 8.67,123.97 8.67,126.39 8.68,126.41 8.68,127.49 12.18,130.98 13.57,132.38 31.59,132.38
+CHARGER_SRC on TOP (solid shape): 195.11,46.92 195.11,44.64 195.04,44.57 194.09,44.57 193.2,45.46 193.2,46.35 192.88,46.67 192.88,46.99 193.14,47.24 194.79,47.24
+CHARGER_SRC on BOTTOM (solid shape): 190.55,48.13 192.5,48.13 192.5,48.68 195.06,48.68 195.17,48.57 195.17,42.73 195.11,42.67 194.53,42.67 193.71,43.49 191.87,43.49 191.74,43.62 191.74,45.84 191.23,46.35 190.09,46.35 189.71,46.73 189.71,48.38 190.01,48.68 190.55,48.68
+DCBAT_LCD on TOP (solid shape): 213.85,61.48 214.33,61.5 214.63,61.19 214.63,58.93 214.56,58.85 213.48,58.85 213.4,58.89 213.37,58.96 212.99,59.32 212.74,58.86 212.75,58.85 212.75,58.74 212.4,58.74 212.4,58.75 211.69,58.75 211.62,58.77 211.59,58.84 211.23,59.16 210.93,58.79 210.91,58.7 210.83,58.67 209.44,58.67 209.21,58.9 209.21,59.63 210.05,60.47 210.46,60.83 210.83,61.25 211.08,61.5 213.51,61.5
+DCBAT_LCD on BOTTOM (solid shape): 213.97,60.64 213.97,59.08 213.78,58.89 213.25,58.89 212.85,59.29 211.88,59.29 211.81,59.37 211.81,60.64 212,60.83 213.78,60.83
+DCBAT_LCD on BOTTOM (solid shape): 211.49,59.56 211.49,58.06 211.49,56.89 211.24,56.64 207.93,56.64 207.74,56.83 207.74,58.67 207.87,58.8 209.33,58.8 210.09,59.56 210.28,59.56 210.54,59.81 211.24,59.81
+DP_VDDC on TOP (solid shape): 117.7,131.25 117.83,131.12 117.83,129.92 117.7,129.79 116.49,129.79 116.37,129.66 116.37,128.71 115.54,127.88 114.42,127.88 114.09,127.55 113.33,127.55 113.3,127.58 113.3,128.7 113.3,128.7 114.46,128.7 114.46,128.68 114.47,128.63 114.48,128.58 114.51,128.53 114.54,128.49 114.57,128.45 114.61,128.42 114.66,128.4 114.71,128.38 114.76,128.37 114.81,128.37 114.87,128.38 114.91,128.4 114.96,128.42 115,128.45 115.04,128.49 115.07,128.53 115.09,128.58 115.11,128.63 115.12,128.68 115.12,128.73 115.11,128.78 115.09,128.83 115.07,128.88 115.04,128.92 115,128.96 114.96,128.99 114.91,129.01 114.87,129.03 114.81,129.04 114.76,129.04 114.71,129.03 114.66,129.01 114.61,128.99 114.57,128.96 114.54,128.92 114.51,128.88 114.48,128.83 114.47,128.78 114.46,128.73 114.46,128.7 113.3,128.7 114.58,129.98 115.74,129.98 116.18,130.42 116.29,130.42 116.52,130.66 117.08,130.66 117.26,130.85 117.26,131.19 117.32,131.25 117.7,131.25
+DP_VDDR on TOP (solid shape): 116.49,131.12 116.49,130.81 116.23,130.55 116.05,130.55 115.67,130.17 113.51,130.17 113.25,129.92 113.25,128.9 113.19,128.84 112.62,128.84 112.56,128.9 112.56,130.87 112.62,130.93 114.46,130.93 114.72,130.68 115.16,130.68 115.35,130.87 115.35,131.12 115.48,131.25 116.37,131.25
+FP_VCC on BOTTOM (solid shape): 218.16,31.37 218.16,30.77 218.16,30.72 218.17,30.67 218.17,30.22 218.05,30.09 216.32,30.09 216.12,30.28 216.12,31.25 216.38,31.5 218.03,31.5
+LAN_VDD33 on TOP (solid shape): 22.56,80.9 22.56,80.4 22.55,80.39 22.55,79.78 22.39,79.61 22.39,78.98 22.08,78.67 21.29,78.67 21.09,78.87 21.09,79.88 21.65,80.44 21.65,80.86 21.78,80.98 22.48,80.98
+LAN_VDD33 on TOP (solid shape): 28.39,80.72 28.41,80.7 29.17,80.7 29.67,80.2 30.14,80.2 30.2,80.14 30.2,79.73 30.19,79.69 30.18,79.66 30.16,79.64 29.61,79.64 29.18,80.06 28.29,80.06 26.79,81.56 25.9,81.56 25.84,81.61 25.84,81.71 25.91,81.78 27.33,81.78
+LAN_VDD33 on TOP (solid shape): 19.81,86.85 19.81,86.01 18.42,84.62 18.41,84.62 18.32,84.58 18.24,84.51 17.31,84.51 17.3,84.5 15.02,84.5 14.96,84.56 14.96,84.9 15.5,84.9 15.5,84.91 15.5,85.39 15.5,85.39 14.94,85.39 14.94,86.14 15,86.2 18.61,86.2 18.89,86.49 18.89,86.85 19.03,86.98 19.68,86.98
+LAN_VDD33 on BOTTOM (solid shape): 21.28,85.44 21.28,84.44 21.02,84.18 21.02,83.82 20.94,83.73 20.27,83.73 19.97,84.03 19.97,85.1 20.35,85.47 21.25,85.47
+LAN_VDD33 on BOTTOM (solid shape): 22.26,80.42 22.26,78.78 22.2,78.72 20.5,78.72 20.38,78.84 20.38,79.98 20.78,80.37 21.21,80.37 21.25,80.42 21.26,80.42 21.31,80.47 22.2,80.47
+LAN_VDD33 on IN3 (solid shape): 27.69,81.44 28.06,81.44 28.18,81.33 28.18,80.7 28.05,80.57 27.29,80.57 25.99,79.27 23.11,79.27 22.58,78.74 21.11,78.74 20.91,78.94 20.91,80.03 21.08,80.2 21.51,80.2 22.31,80.99 22.76,80.99 23.08,80.79 23.4,80.99 23.87,80.99 24.2,80.79 24.52,80.99 24.99,80.99 25.44,80.81 25.65,81.25 25.65,81.28 26.1,81.74 27.39,81.74
+LAN_VDD33 on IN2: 20.37,87.83 21.9,86.3 21.9,78.68 21.86,78.63 20.28,78.63 19.18,79.74 19.19,79.77 19.11,80.17 18.71,80.23 18.61,80.24 18.56,80.33 18.56,83.55 18.4,83.71 18.1,83.71 17.84,84.31 17.58,83.71 15.98,83.71 15.85,83.84 15.85,87.47 16.2,87.83 16.27,87.83 16.36,87.77 16.35,87.67 16.62,87.08 16.89,87.67 16.88,87.77 16.97,87.83
+LCDVDD on TOP (solid shape): 216.95,59.17 217,59.18 217.9,59.18 218.09,58.99 218.09,57.59 217.97,57.46 217.91,57.46 217.84,57.48 217.77,57.49 217.54,57.49 217.47,57.48 217.4,57.46 217.2,57.46 217.08,57.34 217.08,56.07 216.82,55.81 216.19,55.81 215.92,56.08 215.9,56.19 215.99,56.26 216.24,56.26 216.24,56.89 215.63,56.89 215.63,56.87 215.6,56.82 215.54,56.83 215.5,56.87 215.45,56.93 215.47,57.01 215.52,57.3 215.33,57.53 215.3,57.54 215.3,58.61 215.49,58.8 216.38,58.8 216.76,59.18
+LCDVDD_LCD on TOP (solid shape): 214.8,58.54 214.8,57.09 214.66,56.95 214.16,56.95 214.03,56.83 214.03,56.13 213.65,55.75 213.62,55.78 213.27,55.88 213.02,55.62 213.01,55.58 212.52,55.58 212.48,55.62 212.48,58.29 212.48,58.29 212.48,58.39 212.7,58.61 214.73,58.61
+LCDVDD_LCD on BOTTOM (solid shape): 214.09,58.22 214.09,56.32 213.97,56.19 213.15,56.19 213.04,56.31 213.04,56.38 213.05,56.45 213.04,56.52 213.04,56.69 212.95,56.78 211.91,56.78 211.81,56.88 211.81,57.53 211.93,57.65 211.93,57.65 212.96,57.65 213.05,57.74 213.05,58.19 213.15,58.29 214.03,58.29
+MIC2-VREFO on TOP (solid shape): 20.68,14.23 20.68,13.72 20.1,13.14 19.27,13.14 19.11,13.31 19.11,14.23 19.18,14.31 20.61,14.31
+MPLL_PVDD on TOP (solid shape): 128.24,126.55 128.56,126.55 128.69,126.42 128.69,126.11 128.56,125.98 128.24,125.98 128.05,125.79 128.05,125.15 127.99,125.09 127.35,125.09 126.91,124.65 126.91,124.26 126.84,124.2 126.27,124.2 126.21,124.26 126.21,124.71 126.78,125.28 126.78,126.68 126.84,126.74 128.05,126.74
+PCIE_VDDC on TOP (solid shape): 127.69,141.54 127.69,139.91 127.46,139.67 127.44,139.65 127.44,139.19 127.45,139.18 127.45,139.01 127.38,138.94 127.38,138.85 127.3,138.77 126.81,138.77 126.63,138.58 126.63,138.16 126.58,138.11 122.44,138.11 121.85,138.69 121.85,139.34 121.95,139.44 125.38,139.44 125.51,139.57 125.51,140.75 125.8,140.75 125.8,140.69 125.81,140.64 125.82,140.59 125.84,140.54 125.87,140.5 125.91,140.46 125.95,140.42 126,140.4 126.05,140.38 126.1,140.37 126.15,140.36 126.21,140.37 126.26,140.38 126.31,140.4 126.35,140.42 126.4,140.46 126.43,140.5 126.46,140.54 126.49,140.59 126.5,140.64 126.51,140.69 126.51,140.75 126.5,140.8 126.49,140.85 126.46,140.9 126.43,140.94 126.4,140.98 126.35,141.01 126.31,141.04 126.26,141.06 126.21,141.07 126.15,141.08 126.1,141.07 126.05,141.06 126,141.04 125.95,141.01 125.91,140.98 125.87,140.94 125.84,140.9 125.82,140.85 125.81,140.8 125.8,140.75 125.51,140.75 125.51,141.98 125.57,142.05 127.18,142.05
+PCIE_VDDC on IN1: 121.13,142.96 126.69,142.96 127.93,141.72 127.93,139.61 127.93,139.61 127.93,138.35 127.42,137.84 121.08,137.84 120.75,138.17 120.75,142.58
+RTC_CELL on TOP (solid shape): 66.01,33.86 66.01,30.14 65.52,29.65 64.55,29.65 64.04,30.15 64.04,30.79 63.85,30.98 63.6,30.98 63.6,31.58 63.62,31.6 64,31.6 64.74,32.34 64.74,33.86 65.05,34.18 65.69,34.18
+RTC_PWR on TOP (solid shape): 68.09,29.53 68.09,28.31 67.98,28.19 67.22,28.19 66.56,27.54 65.75,27.54 65.65,27.65 65.65,29.07 65.8,29.23 66.19,29.23 66.63,29.66 67.96,29.66
+RTC_SOC on TOP (solid shape): 65.57,38.73 65.57,38.48 65.31,38.22 65.31,34.79 65.12,34.6 64.23,34.6 63.92,34.92 63.92,36.06 64.11,36.25 64.11,38.92 64.14,38.95 65.34,38.95
+SPLL_VDDC on TOP (solid shape): 132.15,124.74 132.15,123.28 132.37,123.06 132.76,123.06 132.88,122.94 132.88,122.68 133.06,122.5 133.04,122.47 133.02,122.44 132.97,122.15 133.19,121.93 133.27,121.91 133.35,121.91 133.42,121.83 133.42,120.33 133.36,120.26 132.75,120.26 132.62,120.39 132.62,121.54 132.42,121.75 132.4,122.24 131.91,122.25 131.88,122.24 131.86,122.24 131.84,122.25 131.54,122.55 131.54,124.84 131.67,124.96 131.92,124.96
+TS_VDD on TOP (solid shape): 216.82,38.54 216.82,37.78 216.57,37.52 216.32,37.52 216.25,37.46 216.18,37.41 216.13,37.34 216,37.21 216,36.84 215.72,36.56 214.02,36.56 213.58,36.99 213.58,37.73 213.71,37.85 213.71,38.68 213.83,38.79 216.57,38.79
+TS_VDD on BOTTOM (solid shape): 213.27,40.83 213.27,39.39 213.11,38.81 213.7,38.92 214.28,38.92 214.54,38.67 216.82,38.67 217.08,38.41 217.08,38.03 216.57,37.52 213.9,37.52 213.78,37.65 212.86,37.65 212.44,38.06 211.84,38.06 211.74,38.16 211.74,40.96 211.9,41.11 212.98,41.11
+TS_VDD_IN on TOP (solid shape): 215.82,36.19 215.82,33.48 215.62,33.28 213.25,33.28 213.09,33.45 212.58,33.45 212.54,33.49 212.54,34.43 214.02,34.43 214.02,34.37 214.03,34.32 214.05,34.27 214.08,34.22 214.11,34.18 214.15,34.15 214.19,34.12 214.24,34.09 214.29,34.08 214.35,34.07 214.4,34.07 214.45,34.08 214.5,34.09 214.55,34.12 214.59,34.15 214.63,34.18 214.67,34.22 214.69,34.27 214.71,34.32 214.72,34.37 214.73,34.43 214.72,34.48 214.71,34.53 214.69,34.58 214.67,34.63 214.63,34.67 214.59,34.7 214.55,34.73 214.5,34.76 214.45,34.77 214.4,34.78 214.35,34.78 214.29,34.77 214.24,34.76 214.19,34.73 214.15,34.7 214.11,34.67 214.08,34.63 214.05,34.58 214.03,34.53 214.02,34.48 214.02,34.43 212.54,34.43 212.54,35.54 213.28,36.28 215.73,36.28
+USB2_VCC on TOP (solid shape): 203.23,36.51 203.23,34.68 203,34.35 203.23,34.02 203.42,34 203.6,34.08 203.64,34.12 203.67,34.17 204.12,33.71 204.12,32.57 203.87,32.32 202.47,32.32 199.68,35.11 198.79,35.11 198.47,35.43 198.47,36.89 198.98,37.4 202.35,37.4
+USB2_VCC on BOTTOM (solid shape): 201.58,37.4 201.58,35.24 201.2,34.86 198.15,34.86 197.77,35.24 197.77,37.27 198.03,37.52 201.46,37.52
+USB3_VCC on TOP (solid shape): outline of 297 points within 14.91,32.3 22.93,53.38
+USB3_VCC on BOTTOM (solid shape): 19.3,60.77 19.3,59.11 19.56,58.85 19.56,52.09 19.15,51.68 17.18,51.68 16.8,52.07 16.8,54.64 16.35,55.08 15.67,55.08 15.3,55.45 15.3,58.38 17.46,58.38 17.46,58.33 17.47,58.27 17.48,58.22 17.5,58.17 17.54,58.13 17.57,58.09 17.61,58.06 17.66,58.03 17.71,58.01 17.76,58 17.81,58 17.87,58 17.92,58.01 17.97,58.03 18.02,58.06 18.06,58.09 18.09,58.13 18.12,58.17 18.15,58.22 18.16,58.27 18.17,58.33 18.17,58.38 18.16,58.43 18.15,58.48 18.12,58.53 18.09,58.57 18.06,58.61 18.02,58.65 17.97,58.67 17.92,58.69 17.87,58.7 17.81,58.71 17.76,58.7 17.71,58.69 17.66,58.67 17.61,58.65 17.57,58.61 17.54,58.57 17.5,58.53 17.48,58.48 17.47,58.43 17.46,58.38 15.3,58.38 15.3,59.37 16.84,60.91 19.16,60.91
+V_DDR_REFA on TOP (solid shape): 71.99,67.75 71.99,67.19 72.03,67.15 72.86,67.15 72.99,67.02 72.99,66.77 72.86,66.64 72.29,66.64 72.1,66.45 72.1,64.4 71.97,64.26 71.48,64.26 71.4,64.35 71.4,67.76 71.44,67.8 71.94,67.8
+V_DDR_REFB on TOP (solid shape): 59.51,70.07 59.51,68.56 59.51,68.56 59.51,67.43 59.57,67.37 60.15,67.37 60.24,67.27 60.24,67.27 60.28,67.23 60.28,66.71 60.18,66.61 58.87,66.61 58.73,66.75 58.73,70.1 58.8,70.17 59.41,70.17
+VGA_CORE on TOP (solid shape): 117.26,124.26 118.72,124.26 118.84,124.14 118.84,122.99 118.72,122.87 115.86,122.87 115.35,123.38 115.35,124.84 115.48,124.96 116.56,124.96
+VGA_CORE on TOP (solid shape): 125.32,136.58 125.32,135.95 125.32,135.95 125.32,135.78 125.69,135.42 126.45,135.42 126.54,135.5 126.78,135.5 126.94,135.35 126.94,134.98 126.94,134.97 127.04,134.87 127.76,134.87 127.97,135.09 127.97,135.6 127.99,135.62 128.52,135.62 128.57,135.57 128.57,133.82 128.47,133.72 128.34,133.64 128.26,133.51 128.18,133.43 128.18,132.52 126.78,131.12 126.15,131.12 126.15,131.12 125.75,131.12 125.38,130.76 125.38,130.73 125.38,130.31 125.38,130.19 126,129.58 126,129.15 125.74,128.89 124.77,128.89 124.68,128.98 124.68,131 125,131.31 125,131.6 124.86,131.74 124.3,131.74 123.86,131.3 123.64,131.3 123.49,131.45 123.49,131.84 123.38,131.94 123.38,132.27 123.41,132.3 126.38,132.3 126.54,132.14 126.9,132.14 126.91,132.14 127.42,132.65 127.42,133.15 127.54,133.28 127.54,134.34 127.47,134.42 126.74,134.42 126.74,134.41 126.74,134.09 126.63,133.98 126.4,133.98 126.32,133.9 124.51,133.9 124.37,134.04 124.37,134.36 124.63,134.62 124.63,136.13 124.37,136.39 124.37,136.58 124.49,136.71 125.19,136.71
+VGA_CORE on TOP (solid shape): outline of 192 points within 118.78,128.49 123.07,137.28
+VGA_CORE on BOTTOM (solid shape): outline of 86 points within 120.56,134.49 122.68,137.18
+VGA_CORE on BOTTOM (solid shape): outline of 190 points within 94.78,120.33 107.98,141.85
+VGA_CORE on BOTTOM (solid shape): outline of 276 points within 119.54,128.13 127.87,137.12
+VGA_CORE on IN1: 119.34,135.26 121.77,137.68 123.39,137.68 123.49,137.63 123.48,137.52 123.55,137.02 124.05,137.1 124.14,137.15 124.23,137.1 124.75,136.98 124.8,137.51 124.78,137.62 124.87,137.68 127.18,137.68 127.8,137.06 127.8,132.89 127.93,132.76 127.93,132.55 127.93,132.38 127.23,131.68 127.23,129.34 127.67,128.91 127.67,128.27 127.54,128.14 126.84,128.14 126.34,128.65 120.05,128.65 119.34,129.35
+VGA_CORE on VCC: 100.87,119.55 96.68,123.74 96.68,144.35 97.42,145.09 125.99,145.09 125.99,136.33 127.89,134.43 127.89,132.74 126.62,131.47 126.62,129.98 127.89,128.71 127.89,127.02 125.99,125.12 125.99,119.55
+VGA_CORE on IN2: 125.69,122.24 123.74,120.29 118.4,120.29 118.4,120.29 107.86,120.29 107.86,120.29 106.86,120.29 106.78,120.37 103.73,120.37 102.08,122.02 102.08,125.6 104.68,128.2 104.68,128.77 104.76,128.85 104.76,131.87 104.68,131.94 104.68,132.65 102.21,135.12 102.21,144.99 103.35,146.13 126.15,146.13 126.86,145.42 126.86,144.86 126.87,144.49 127.22,144.37 127.25,144.37 127.93,143.69 127.93,138.74 127.92,138.74 127.92,132.14 127.56,131.78 127.52,131.74 127.39,131.61 127.39,129.42 127.8,129.01 127.8,128.43 127.5,128.13 127.48,128.13 127.2,127.96 127.17,127.63 127.18,127.62 127.18,127.5 127,127.12 127.31,126.83 127.36,126.83 127.36,124.89 127.34,124.85 127.31,124.84 126.98,124.48 127.31,124.13 127.34,124.11 127.36,124.08 127.36,123.91 126.16,122.71 125.89,122.71 125.69,122.5
+VGA_CORE on IN3: outline of 83 points within 115.22,124.13 127.94,136.61
+VGA_CORE_TOPAZ on TOP (solid shape): 121.7,124.58 121.7,124.26 121.69,124.18 121.7,124.09 121.7,123.38 121.26,122.93 119.6,122.93 119.41,123.12 119.41,124.14 119.48,124.2 120.62,124.2 121.26,124.84 121.45,124.84
+VGA_CORE_TOPAZ on BOTTOM (solid shape): 124.56,128.33 124.56,127.95 124.37,127.76 123.03,127.76 122.55,127.27 122.54,127.27 122.43,127.2 122.37,127.09 122.36,127.09 122.12,126.85 122.09,126.86 121.81,126.87 121.64,126.66 121.63,126.61 121.19,126.61 120.49,127.31 120.49,127.5 120.68,127.69 120.94,127.69 121.15,127.91 121.19,127.89 121.57,127.95 121.63,128.34 121.61,128.37 121.7,128.46 124.43,128.46
+VGA_CORE_TOPAZ on BOTTOM (solid shape): 118.91,132.39 118.91,131.82 119.16,131.57 119.41,131.57 119.6,131.38 119.6,130.86 119.41,130.68 119.41,130.54 119.41,130.31 119.41,130.3 119.6,130.11 119.6,129.85 119.48,129.73 119.48,129.72 119.41,129.65 119.41,129.36 119.48,129.29 119.48,129.28 119.6,129.15 119.6,128.85 119.34,128.58 118.46,128.58 118.27,128.39 117.95,128.39 117.83,128.52 117.83,128.84 118.14,129.15 118.14,129.39 118.16,129.43 118.19,129.44 118.51,129.77 118.19,130.1 118.16,130.12 118.14,130.15 118.14,130.61 118.11,130.65 118.11,131.39 118.2,131.48 118.21,131.5 118.21,132.27 118.4,132.46 118.84,132.46
+VGA_CORE_TOPAZ on IN1: 124.43,124.2 124.43,128.01 123.99,128.46 119.99,128.46 119.16,129.28 119.16,132.71 118.94,132.93 116.21,132.93 115.35,132.08 115.35,124.26 116.49,123.12 123.35,123.12
AUD_AGND on TOP (solid shape): 21.93,15.53 21.39,15.53 21.22,15.71 20.86,15.71 20.68,15.53 20.18,15.53 20.18,17 21.93,17
AUD_AGND on TOP (solid shape): 26,19.62 26.39,19.24 27.15,19.24 27.15,17.58 26.96,17.39 26.7,17.39 26.58,17.27 26.58,15.58 26.23,15.24 26.23,14.51 26.06,14.34 25.57,14.34 25.43,14.47 25.43,15.11 25.12,15.43 25.12,15.82 25.12,15.87 25.12,16.82 24.74,17.2 24.74,19.62 25.37,20.25 26,20.25
AUD_AGND on TOP (solid shape): 29.94,10.85 29.94,10.09 29.43,9.58 29.12,9.58 28.99,9.46 28.99,9.45 28.91,9.37 28.63,9.37 28.63,8.53 28.64,8.53 28.64,8.22 28.42,8 28.42,7.3 27.78,7.3 27.78,7.42 27.47,7.74 26.7,7.74 26.64,7.81 26.64,8.76 26.89,9.01 27.4,9.01 27.59,9.01 27.85,9.27 28.16,9.27 29.82,10.92 29.88,10.92
AUD_AGND on GND1, GND2: 10.07,5.3 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.47,18.92 4.7,19.36 14.79,19.36 15.93,18.22 17.54,18.22 18.55,19.24 22.24,19.24 23.13,20.12 26.05,20.12 26.56,20.63 33.71,20.63 33.94,20.4 33.94,15.66 33.46,15.17 29.9,15.17 29.5,14.77 29.5,12.76 25.89,12.76 25.25,12.12 23.98,12.12 23.6,11.74 23.42,11.74 23.28,11.59 23.28,9.48 23.8,8.95 27.95,8.95 29.86,10.85 30.77,10.85 30.77,9.89 30.26,9.38 30.26,8.17 29.39,7.3 27.83,7.3 27.32,7.81 23.38,7.81 22.24,8.95 17.07,8.95 14.41,6.28 10.98,6.28 10.07,5.37
AUD_AGND on VCC: 10.07,5.3 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.47,18.92 4.7,19.36 14.79,19.36 15.93,18.22 17.54,18.22 18.55,19.24 22.24,19.24 23.13,20.12 26.05,20.12 26.56,20.63 33.71,20.63 33.94,20.4 33.94,15.66 33.46,15.17 29.9,15.17 29.5,14.77 29.5,12.76 25.89,12.76 25.25,12.12 23.98,12.12 23.6,11.74 23.42,11.74 23.28,11.59 23.28,9.48 23.8,8.95 27.95,8.95 29.86,10.85 30.77,10.85 30.77,9.89 30.26,9.38 30.26,8.17 29.39,7.3 27.83,7.3 27.32,7.81 23.38,7.81 22.24,8.95 17.07,8.95 14.41,6.28 10.98,6.28 10.07,5.37
AUD_SPK_L+ on TOP (solid shape): 29.56,5.9 29.56,5.39 29.43,5.27 27.85,5.27 27.85,6.03 29.43,6.03
AUD_SPK_L+ on TOP (solid shape): 31.55,10.85 31.55,10.04 31.61,9.99 31.61,9.38 31.43,9.2 31.43,8.31 31.35,8.24 31.02,8.24 30.95,8.31 30.95,9.18 31.35,9.58 31.35,10.85 31.4,10.9 31.5,10.9
AUD_SPK_L+ on BOTTOM (solid shape): 31.4,9.2 31.4,6.98 31.4,6.97 31.4,6.76 29.78,5.14 28.61,5.14 28.48,5.27 28.48,5.9 28.61,6.03 29.22,6.03 30.39,7.2 30.39,9.01 30.7,9.33 31.28,9.33
AUD_SPK_L+_C on TOP (solid shape): 27.27,6.03 27.59,6.03 27.59,5.27 26.2,5.27 26.13,5.33 26.13,5.77 25.43,6.47 25.1,6.47 25.07,6.5 24.77,6.5 24.74,6.47 22.64,6.47 22.13,5.96 17.11,5.96 14.96,3.81 14.26,3.81 14.13,3.93 14.13,4.76 14.32,4.95 14.7,4.95 16.67,6.92 20.92,6.92 21.37,7.36 21.5,7.49 25.81,7.49
AUD_SPK_L+_C on BOTTOM (solid shape): 14.96,6.59 14.96,3.95 14.82,3.81 13.98,3.81 13.86,3.92 13.86,6.6 13.92,6.66 14.88,6.66
AUD_SPK_L- on TOP (solid shape): 29.56,4.63 29.56,4.12 29.43,4 27.85,4 27.85,4.76 29.43,4.76
AUD_SPK_L- on TOP (solid shape): 31.96,10.85 31.96,10.02 32.01,9.96 32.01,9.25 32.06,9.2 32.06,8.69 32.16,8.59 32.16,8.31 32.09,8.24 31.66,8.24 31.58,8.31 31.58,9.15 31.73,9.3 31.73,9.99 31.76,10.02 31.76,10.85 31.81,10.9 31.91,10.9
AUD_SPK_L- on IN3 (solid shape): 32.09,9.25 32.09,8.77 32.29,8.57 32.29,5.8 30.49,4 28.61,4 28.48,4.12 28.48,4.69 28.61,4.82 29.89,4.82 31.43,6.36 31.43,8.06 31.56,8.19 31.56,9.23 31.66,9.33 32.01,9.33
AUD_SPK_L-_C on TOP (solid shape): 22.64,5.08 25.05,5.08 25.12,5.01 27.4,5.01 27.59,4.82 27.59,4 25.39,4 25.2,4.19 21.31,4.19 20.73,4.76 17.69,4.76 15.34,2.41 14.26,2.41 14.13,2.54 14.13,3.42 14.26,3.55 15.08,3.55 17.24,5.71 22,5.71
AUD_SPK_L-_C on BOTTOM (solid shape): 13.73,6.49 13.73,3.82 14,3.55 14.51,3.55 14.64,3.42 14.64,2.54 14.51,2.41 13.69,2.41 12.4,3.69 12.4,6.55 12.51,6.66 13.56,6.66
AUD_SPK_R+ on TOP (solid shape): 24.48,1.96 24.48,1.33 24.35,1.2 22.83,1.2 22.77,1.27 22.77,2.03 22.83,2.09 24.35,2.09
AUD_SPK_R+ on TOP (solid shape): 32.77,10.85 32.77,9.91 33.56,9.13 33.56,8.62 33.46,8.52 33.13,8.52 33.05,8.59 33.05,8.95 32.82,9.18 32.82,9.41 32.52,9.71 32.52,9.99 32.55,10.02 32.55,10.85 32.6,10.9 32.72,10.9
AUD_SPK_R+ on IN3 (solid shape): 33.94,9.03 33.94,6.26 33.64,5.95 33.64,4.5 30.31,1.18 23.58,1.18 23.4,1.35 23.4,2.01 23.58,2.19 29.93,2.19 32.62,4.88 32.62,6.36 32.95,6.69 32.95,8.09 33.1,8.24 33.1,8.9 32.83,9.18 32.83,9.41 32.93,9.51 33.46,9.51
AUD_SPK_R+_C on TOP (solid shape): 20.54,2.15 22.39,2.15 22.51,2.03 22.51,1.27 22.45,1.2 18.89,1.2 18.45,1.65 18.45,2.92 18.64,3.11 19.59,3.11
AUD_SPK_R+_C on BOTTOM (solid shape): 19.72,5.52 19.72,2.79 19.59,2.66 18.77,2.66 18.64,2.79 18.64,4.76 18.26,5.14 16.29,5.14 16.1,5.33 16.1,6.47 16.23,6.6 18.64,6.6
AUD_SPK_R- on TOP (solid shape): 26.64,2.98 26.64,2.41 26.51,2.28 24.99,2.28 24.93,2.34 24.93,3.11 26.51,3.11
AUD_SPK_R- on TOP (solid shape): 32.37,10.85 32.37,10.02 32.39,9.99 32.39,9.63 32.7,9.33 32.7,9.1 32.93,8.87 32.93,8.42 32.82,8.31 32.47,8.31 32.39,8.39 32.39,8.64 32.24,8.8 32.24,9.28 32.14,9.38 32.14,10.85 32.19,10.9 32.32,10.9
AUD_SPK_R- on BOTTOM (solid shape): 32.7,9.23 32.7,9.1 32.95,8.85 32.95,8.59 33.21,8.34 33.21,6.74 31.35,4.88 31.35,4.05 29.4,2.09 25.75,2.09 25.57,2.28 25.57,3.04 25.69,3.16 28.93,3.16 30.2,4.43 30.2,5.25 32.19,7.23 32.19,7.98 32.34,8.14 32.34,8.69 32.22,8.82 32.22,9.23 32.32,9.33 32.6,9.33
AUD_SPK_R-_C on TOP (solid shape): 20.92,3.93 24.7,3.93 24.78,3.85 24.78,3.14 24.67,3.03 24.67,2.34 23.34,2.34 23.21,2.47 23.21,3.04 23.08,3.17 20.04,3.17 19.78,3.42 18.07,3.42 17.94,3.55 17.94,4.38 18.07,4.5 20.35,4.5
AUD_SPK_R-_C on BOTTOM (solid shape): 15.72,6.54 15.72,5.14 16.29,4.57 18.26,4.57 18.38,4.44 18.38,3.61 18.26,3.49 15.97,3.49 15.08,4.38 15.08,6.54 15.21,6.66 15.59,6.66
BOOT1_CHG on BOTTOM (solid shape): 203.04,45.4 203.04,45.27 202.98,45.21 201.27,45.21 200.63,44.57 200,44.57 200,45.46 202.98,45.46
BST1_VGA on TOP (solid shape): 77.17,127.94 77.17,127.45 77.38,127.25 77.89,127.25 78.06,127.42 78.06,127.67 78.08,127.69 78.71,127.69 78.77,127.63 78.77,126.87 78.58,126.68 77.54,126.68 77.53,126.68 77.38,126.72 77.23,126.68 77.22,126.68 76.97,126.68 76.41,127.24 76.41,127.66 76.27,127.8 76.27,127.96 76.32,128.01 77.1,128.01
BST2_VGA on TOP (solid shape): 77.5,134.17 77.5,133.33 77.35,133.13 77.37,132.89 77.37,132.62 77.18,132.43 77.18,131.46 77.11,131.39 76.34,131.39 76.26,131.47 76.26,132.71 76.54,132.99 76.54,133.61 76.74,133.81 76.74,134.17 76.81,134.23 77.44,134.23
BST_1.2V on TOP (solid shape): 40.3,30.68 40.3,29.64 40.21,29.55 40.18,29.55 39.59,29.34 39.33,28.78 39.25,28.7 37.98,28.7 37.94,28.75 37.94,28.87 37.99,28.92 38.79,28.92 39.13,29.27 39.26,29.27 39.44,29.45 39.44,30.7 39.53,30.79 40.19,30.79
BST_1.05V on BOTTOM (solid shape): 162.09,43.68 162.09,43.53 163.23,42.39 163.23,41.71 163.17,41.65 162.72,41.65 162.59,41.78 162.59,42.16 162.09,42.67 161.96,42.67 161.77,42.86 161.77,43.68 161.83,43.75 162.02,43.75
BST_3V on BOTTOM (solid shape): 21.47,41.26 21.47,40.58 21.36,40.47 21.36,39.54 21.32,39.51 20.66,39.51 20.61,39.56 20.61,40.39 20.68,40.47 20.68,41.03 20.66,41.05 20.66,41.79 20.74,41.87 20.86,41.87
BST_3V_R on BOTTOM (solid shape): 23.68,40.62 23.68,40.22 23.61,40.14 22.89,40.14 22.69,39.94 22.69,39.53 22.64,39.48 22.06,39.48 21.99,39.54 21.99,40.56 22.16,40.72 23.58,40.72
BST_5V on BOTTOM (solid shape): 24.23,100.45 24.23,99.77 24.79,99.21 24.79,98.37 24.75,98.32 24.56,98.32 24.28,98.6 24.18,98.85 23.93,98.95 23.91,98.98 23.81,99.15 23.64,99.24 23.28,99.61 23.28,100.45 23.34,100.52 24.16,100.52
BST_5V_R on BOTTOM (solid shape): 23.99,102.73 23.99,102.19 24.23,101.94 24.23,101.28 24.16,101.21 23.25,101.21 23.15,101.32 23.15,101.52 22.77,101.9 22.77,102.47 23.1,102.8 23.91,102.8
BST_+1.35VGPU_R on TOP (solid shape): 147.42,108.56 147.42,107.91 147.35,107.83 146.82,107.83 146.64,107.65 145.5,107.65 145.45,107.7 145.45,108.57 145.52,108.64 147.33,108.64
BST_VCCSA on TOP (solid shape): 168.69,55.38 168.69,55.1 169.2,54.6 169.2,54.29 169.07,54.16 168.22,54.16 167.92,54.46 167.92,55.45 167.97,55.51 168.56,55.51
BST_VCCSA_R on TOP (solid shape): 167.32,55.41 167.32,54.48 167.47,54.33 167.47,53.58 167.38,53.5 166.59,53.5 166.54,53.55 166.54,54.34 166.48,54.4 166.48,55.45 166.56,55.53 167.19,55.53
