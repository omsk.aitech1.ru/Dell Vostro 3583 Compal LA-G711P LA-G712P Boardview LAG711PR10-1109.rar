# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWM1_2PH_CPU: length 21.4
  TOP w0.112: v1(161.36,67.33) v2(160.99,67.7)
  IN1 w0.254: v1(171.1,54.49) 171.1,54.48 170.74,54.48 170.26,54.97 170.26,57.29 168.63,58.92 168.63,62.03 163.8,66.86 161.83,66.86 v1(161.36,67.33)
  BOTTOM w0.203: PUZ01.16 171.51,54.9 v1(171.1,54.49)
  BOTTOM w0.254: PUI01.1 162.02,66.8 161.49,67.33 v1(161.36,67.33)
PWM2_2PH_CPU: length 52.5
  TOP w0.112: v1(162.72,68.45) v2(162.21,68.45)
  IN1 w0.254: v1(172.39,68.77) 172.39,70.91 166.15,77.15 166.15,87.49 v1(166.99,88.33) ; v1(162.72,68.45) 162.91,68.45 169.07,62.29 169.07,59.05 170.61,57.51 170.61,55.26 v1(170.85,55.03)
  IN3 w0.254: v1(162.72,68.45) 163.55,68.45 164.25,69.15 172,69.15 v1(172.39,68.77)
  BOTTOM w0.203: v1(170.85,55.03) 170.85,55.03 171.1,55.03 171.36,55.3 PUZ01.17
  BOTTOM w0.254: PUI02.1 166.92,88.26 v1(166.99,88.33)
PWM_1A_CPU: length 52.4
  TOP w0.112: v2(158.72,96.51) 158.23,96.02 v1(158.07,96.02)
  IN2 w0.254: v1(158.07,96.02) 158.07,95.71 158.34,95.44 159.99,95.44 160.5,95.94 163.64,95.94 165.9,93.68 165.9,87.24 166.11,87.03 166.11,84.3 165.56,83.75 165.56,74.15 163.75,72.34 163.75,69.44 165.39,67.8 165.39,65.15 168.39,62.15 168.39,60.7 v1(171.07,58.02)
  BOTTOM w0.203: v1(171.07,58.02) 171.79,57.3 PUZ01.22
  BOTTOM w0.254: v1(158.07,96.02) 157.84,95.79 PUG01.1
PWM_1B_CPU: length 20.3
  TOP w0.112: v2(179.9,60.56) v1(179.9,59.94)
  IN2 w0.254: v1(179.9,59.94) 179.39,60.45 177.07,60.45 176.18,59.56 173.01,59.56 171.93,58.48 171.93,53.78 171.43,53.28 170.58,53.28 170.4,53.46 v1(169.96,53.46)
  BOTTOM w0.203: PUZ01.36 177.63,59.27 177.72,59.36 179.04,59.36 179.61,59.94 v1(179.9,59.94)
  BOTTOM w0.254: v1(169.96,53.46) 169.85,53.35 PUA01.2
PWRGD_VGA: length 6.5
  TOP w0.203: 78.58,125.73 77.95,126.36 76.46,126.36 75.98,126.84 PUV01.20
  TOP w0.254: 78.58,125.73 v2(78.58,125.33) PRV17.2 78.58,123.47 PRV37.1 78.57,123.44 PRV20.1
PX_EN: length 1.5
  TOP w0.102: TP79.1 119.08,133.1 v1(118.82,133.36)
  BOTTOM w0.102: v1(118.82,133.36) 118.98,133.36 UV1.AB16
QPCN_CHG: length 1.3
  BOTTOM w0.112: PCB18.2 203.79,41.22 v2(203.79,40.5)
QPCP_CHG: length 1
  BOTTOM w0.112: PCB18.1 205.99,41.65 v2(206.13,41.51)
REFCLK_CNV: length 178.8
  IN1 w0.119: v1(147.91,67.28) 143.14,72.06 143.14,72.1 141.4,73.83 141.18,74.05 141.18,95 141.51,95.33 141.51,103.49 139.87,105.13 134.21,105.13 132.99,106.36 131.87,106.36 130.25,107.97 126.99,107.97 122.02,112.95 113.85,112.95 112.76,114.04 102.9,114.04 102.05,113.19 96.96,113.19 v1(92.93,117.22)
  IN3 w0.135: v1(92.93,117.22) 92.9,117.25 92.52,117.25 88.62,121.15 78.71,121.15 77.44,122.42 74.73,122.42 73.53,123.62 69.42,123.62 68.6,122.8 64.24,122.8 63.41,123.63 63.41,130.93 v1(68.79,136.32)
  BOTTOM w0.112: v1(147.91,67.28) 147.58,66.95 147.58,59.29 151.01,55.86 151.01,52.42 150.47,51.87 149.51,51.87 149.13,51.49 149.13,49.18 148.77,48.83 148.26,48.83 147,47.57 147,45.94 147,44.31 146.2,43.51 144.92,43.51 143.42,45.02 142.91,45.02 142.02,45.91 RC84.2 ; v1(68.79,136.32) 69.16,135.95 70.39,135.95 70.84,136.4 JWLAN1.64
REFCLK_CNV_R: length 8.8
  BOTTOM w0.076: 136.98,47.99 136.88,48.09 136.88,48.59 136.71,48.76 136.43,48.76 136.18,49.02 135.92,49.02 135.7,49.24 135.7,49.78 UC1.CM3
  BOTTOM w0.112: RC84.1 140.8,45.87 RC86.1 140.37,45.14 v2(139.85,45.66) 138.08,47.43 137.3,47.43 136.98,47.75 136.98,47.99
REGOUT:
  vias: v2(21.07,84.56)
RESET_OUT#: length 127.1
  TOP w0.112: v1(47.54,80.45) 47.46,80.45 46.55,81.36 UE1.73 ; v2(116.82,59.95) 116.93,59.84 v1(117.31,59.84) ; RE24.1 CE30.1 v1(49.9,85.54)
  IN2 w0.124: v1(52.61,79.18) 52.3,78.87 52.3,75.94 53.02,75.21 53.02,70.01 55.11,67.92 55.11,49.57 57.8,46.88 57.8,44.47 58.18,44.08 61.28,44.08 61.84,43.53 63.1,43.53 63.82,42.81 69.98,42.81 70.76,42.03 73.33,42.03 74.6,43.3 75.5,43.3 76.13,42.67 76.13,42.4 76.51,42.03 77.84,42.03 79.42,43.61 80.59,43.61 81.26,44.28 85.69,44.28 89.58,48.18 100.54,48.18 101.36,49 103.33,49 103.8,49.47 103.99,49.47 106.81,52.29 108.78,52.29 114.33,57.85 114.33,58.73 115.44,59.84 v1(117.31,59.84)
  IN3 w0.135: v1(49.9,85.54) 48.06,83.69 48.06,80.96 v1(47.54,80.45)
  BOTTOM w0.089: UC1.BP31 v1(117.31,59.84)
  BOTTOM w0.119: v1(52.61,79.18) 52.1,79.69 52.1,84.42 50.99,85.54 v1(49.9,85.54)
RING2: length 12.2
  TOP w0.127: v1(32.77,17) 32.8,17.03 v2(32.8,17.61)
  BOTTOM w1.016: 22,15.11 24.29,17.39 30.96,17.39 31.47,17.9 32.42,17.9
  vias: v1(21.05,15.26) v1(21.05,14.66) v1(32.77,16.42)
RING2_R: length 25.8
  TOP w0.127: v2(23.53,18.65) 23.26,18.39 DA5.3
  IN1 w1.016: JHP1.4 6.02,6.73 14.13,6.73 15.73,8.32 15.73,14.79 16.74,15.81 18.7,15.81 20.35,17.46
  vias: v1(21.14,18.66) v1(21.14,18.03)
RJ45_MDIN0: length 8.8
  TOP w0.267: TL1.2 16.53,71.86 15.15,73.24 v4(15.15,73.71) 15.15,77.52 14.88,77.78 14.38,77.78 14.32,77.72 14.02,77.41 JLAN1.2
RJ45_MDIN1: length 17
  TOP w0.267: TL1.8 16.19,64.24 15.66,64.78 v4(14.93,64.78) 14.21,64.78 13.72,65.27 13.72,67.86 13.66,67.93 13.66,68.04 v1(13.57,68.13)
  IN1 w0.203: JLAN1.6 14.05,73.38 15.2,74.53 15.71,74.53 15.96,74.28 15.96,72.71 14.99,71.75 14.99,70.22 13.67,68.9 13.67,68.23 v1(13.57,68.13)
RJ45_MDIN2: length 5.1
  BOTTOM w0.267: TL2.7 16.71,71.86 16.38,72.19 15.75,72.19 15.1,72.85 15.1,73.45 14.91,73.64 JLAN1.5
RJ45_MDIN3: length 10.5
  BOTTOM w0.267: JLAN1.8 13.9,70.73 13.9,71.15 14.07,71.32 14.61,71.32 15.02,70.91 15.02,69.3 14.64,68.92 v4(14.64,65.79) 14.64,65.37 15.03,64.98 15.36,64.98 16.1,64.24 TL2.1
RJ45_MDIP0: length 8.8
  TOP w0.267: JLAN1.1 13.83,77.75 14.04,77.98 14.22,78.16 15.04,78.16 15.53,77.67 v4(15.53,75.75) 15.53,73.4 15.79,73.13 TL1.1
RJ45_MDIP1: length 17
  TOP w0.267: v1(14.15,68.13) 14.11,68.09 14.11,65.43 14.37,65.16 15.86,65.16 16.21,65.51 TL1.7
  IN1 w0.203: v1(14.15,68.13) 14,68.28 14,68.76 15.32,70.09 15.32,71.61 16.29,72.58 16.29,74.42 15.85,74.86 15.4,74.86 14.58,75.68 JLAN1.3
RJ45_MDIP2: length 5.1
  BOTTOM w0.267: JLAN1.4 13.94,74.66 13.76,74.48 13.76,74.24 13.98,74.02 15.07,74.02 15.48,73.61 15.48,73.01 15.91,72.58 16.15,72.58 16.7,73.13 TL2.8
RJ45_MDIP3: length 10.5
  BOTTOM w0.267: JLAN1.7 13.81,71.6 13.91,71.7 14.77,71.7 15.4,71.06 15.4,69.15 15.02,68.77 15.02,65.56 15.22,65.36 15.95,65.36 16.1,65.51 TL2.2
ROSC_COREGT_CPU: length 2.9
  BOTTOM w0.112: PRZ64.1 170.52,53.81 v2(170.52,54.2)
  BOTTOM w0.203: PUZ01.14 171.98,54.1 PRZ64.1
ROSC_SAUS_CPU: length 4
  TOP w0.112: v2(169.45,53.63) 169.73,53.9 v1(171.1,53.9)
  TOP w0.254: v1(171.1,53.9) 171.2,53.8 PRZ60.1
  BOTTOM w0.203: v1(171.1,53.9) 171.26,53.9 171.86,54.5 PUZ01.15
RTC_DET#: length 81.2
  TOP w0.254: v1(62.66,38.16) 62.75,38.08 62.75,37.4 63,37.14 v2(63,37.09) 63,35.39 64.23,34.16 64.23,32.38 63.72,31.87 61.69,31.87 61.38,31.55 Q1.1
  IN2 w0.124: v1(62.66,38.16) 62.84,38.35 63.47,38.35 63.91,37.92 70.9,37.92 71.45,38.46 76.12,38.46 76.42,38.17 78.45,38.17 80.88,40.6 81.83,40.6 82.51,41.28 90.77,41.28 91.21,41.72 93.65,41.72 94.26,42.33 107.57,42.33 110.85,45.62 111.71,45.62 113.71,47.61 116.67,47.61 117.47,48.4 121.14,48.4 123.02,46.52 v1(123.02,46.35)
  BOTTOM w0.076: v1(123.02,46.35) 123.15,46.35 123.23,46.43 123.23,47.6 123.05,47.78 123.05,47.99 123.13,48.18 123.13,48.41 UC1.CP22
  BOTTOM w0.112: RC111.2 122.78,44.9 122.78,45.93 123.02,46.17 v1(123.02,46.35)
RTCRST_ON: length 72.1
  TOP w0.112: UE1.31 49.35,69.49 v1(48.93,69.91) ; v1(58.33,28.13) 58.32,28.13 57.86,28.58 57.86,29.16 v2(57.88,29.18) 59.28,30.58 59.28,33.27 59.39,33.38 R65.2
  IN1 w0.119: v1(39.15,61.99) 39.45,62.29 39.59,62.29 41.56,64.26 46.71,64.26 47.46,63.5 48.5,63.5 v1(48.64,63.64)
  IN2 w0.124: v1(58.33,28.13) 57.25,29.21 57.25,29.92 54.21,32.95 50.03,32.95 44,38.98 44,53.88 44.93,54.81 44.93,58.04 44,58.96 42.1,60.86 41.22,60.86 40.1,61.99 v1(39.15,61.99)
  IN3 w0.135: v1(48.64,63.64) 48.64,69.62 v1(48.93,69.91)
RTCRST_ON_R: length 1.1
  TOP w0.112: Q18.2 v2(59.46,36.45)
RUNPWROK: length 2.4
  TOP w0.112: RE41.2 53.22,75.05 52.9,75.37 52.28,75.37 52.25,75.41 UE1.48
SATA_CRX_C_DTX_N0: length 9.9
  BOTTOM w0.112: CS17.2 179.87,33.26 v4(180.91,33.26) 181.5,33.26 182.68,34.43 187.96,34.43 188.2,34.68 JHDD1.5
SATA_CRX_C_DTX_N1: length 5.4
  BOTTOM w0.112: JODD1.10 189.2,66.62 189.58,66.23 189.58,65.37 189.46,65.25 189.46,65.24 189.2,64.98 JODD1.9 189.2,63.62 189.59,63.23 189.59,62.82 CO6.1
SATA_CRX_C_DTX_P0: length 9.9
  BOTTOM w0.112: CS18.2 180.37,33.49 181.43,33.49 182.59,34.65 187.87,34.65 187.98,34.77 187.98,34.87 187.7,35.15 JHDD1.6
SATA_CRX_C_DTX_P1: length 5.5
  BOTTOM w0.112: CO7.1 189.81,62.96 189.81,63.23 190.2,63.62 JODD1.11 190.2,64.96 189.8,65.36 189.8,66.21 190.2,66.6 JODD1.12
SATA_CRX_DTX_N0: length 69.9
  IN3 w0.089: v1(131.51,60.61) 131.51,60.59 131.58,60.53 131.58,60.25 131.49,60.16 130.57,60.16 129.92,59.5 129.92,56.16 130.63,55.44 134.43,55.44 134.45,55.42
  IN3 w0.135: 134.45,55.42 136.95,52.92 136.95,52.35 141.57,47.74 141.57,44.85 144.43,41.99 144.43,41.1 149.02,36.51 152.35,36.51 152.94,35.92 163.15,35.92 164.34,34.73 168.06,34.73 168.95,33.83 170.1,33.83 172.79,31.14 175.39,31.14 175.7,31.45 175.81,31.45 v1(175.99,31.27)
  BOTTOM w0.102: UC1.BN10 131.05,61.07 v1(131.51,60.61)
  BOTTOM w0.112: CS17.1 178.63,33.42 177.88,33.42 176.93,32.47 176.93,31.77 176.56,31.4 176.12,31.4 v1(175.99,31.27)
SATA_CRX_DTX_N1: length 108.4
  IN1 w0.119: v1(189.48,60.84) 189.66,60.66 189.66,60.33 189.24,59.9 187.59,59.9 181.89,54.21 181.89,47.69 176.74,42.55 176.74,36.23 175.22,34.71 175.22,31.9 174.46,31.14 174.46,30.21 v1(174.25,30)
  IN3 w0.089: v1(132.88,62.56) 132.88,62.29 132.76,62.17 131.6,62.17 129.54,60.11 129.54,56 129.96,55.58 129.96,55.18 130.62,54.52 134.36,54.52 135.75,53.13
  IN3 w0.135: v1(174.25,30) 174.44,30.19 174.44,30.38 174.36,30.46 172.51,30.46 169.82,33.15 168.67,33.15 167.77,34.05 164.06,34.05 162.99,35.11 149.46,35.11 143.75,40.82 143.75,41.71 140.89,44.57 140.89,47.45 138.08,50.26 137.27,50.26 135.75,51.79 135.75,53.13
  BOTTOM w0.076: UC1.BL6 133.05,61.84 132.96,61.84 132.85,61.94 132.85,62.06 133.09,62.3 133.09,62.41 132.94,62.56 v1(132.88,62.56)
  BOTTOM w0.112: CO6.2 189.66,61.18 189.66,61.02 v1(189.48,60.84)
SATA_CRX_DTX_P0: length 69.9
  IN3 w0.089: 134.59,55.62 130.7,55.62 130.09,56.23 130.09,59.43 130.64,59.98 131.57,59.98 131.76,60.17 131.76,60.28 132.15,60.67 v1(132.18,60.67)
  IN3 w0.135: v1(175.99,31.86) 175.83,31.69 175.6,31.69 175.29,31.38 172.89,31.38 170.2,34.07 169.05,34.07 168.16,34.97 164.44,34.97 163.25,36.16 153.04,36.16 152.45,36.75 149.12,36.75 144.67,41.2 144.67,42.09 141.81,44.95 141.81,47.84 137.19,52.45 137.19,53.02 134.59,55.62
  BOTTOM w0.076: v1(132.18,60.67) 132.24,60.74 132.24,60.97 132.11,61.1 131.93,61.1 UC1.BN8
  BOTTOM w0.112: CS18.1 178.45,33.64 177.79,33.64 176.71,32.56 176.71,31.86 176.47,31.62 176.22,31.62 v1(175.99,31.86)
SATA_CRX_DTX_P1: length 108.5
  IN1 w0.119: v1(174.83,30) 174.68,30.16 174.68,31.05 175.44,31.81 175.44,34.62 176.96,36.14 176.96,42.46 182.11,47.6 182.11,54.12 187.68,59.69 189.33,59.69 189.88,60.24 189.88,60.66 v1(190.06,60.84)
  IN3 w0.089: v1(132.74,61.55) 132.87,61.55 133.03,61.71 133.03,61.89 132.94,61.98 131.68,61.98 129.73,60.03 129.73,56.06 130.13,55.66 130.13,55.25 130.69,54.69 134.5,54.69 135.99,53.21
  IN3 w0.135: 135.99,53.21 135.99,51.89 137.37,50.5 138.18,50.5 141.13,47.55 141.13,44.67 143.99,41.81 143.99,40.92 149.56,35.35 163.09,35.35 164.16,34.29 167.87,34.29 168.77,33.39 169.92,33.39 172.61,30.7 174.46,30.7 174.68,30.48 174.68,30.15 v1(174.83,30)
  BOTTOM w0.076: UC1.BL5 133.41,61.55 v1(132.74,61.55)
  BOTTOM w0.112: v1(190.06,60.84) 189.88,61.02 189.88,61.18 CO7.2
SATA_CTX_C_DRX_N0: length 13.8
  BOTTOM w0.112: JHDD1.3 189.2,34.89 189.48,34.61 189.48,33.74 186.14,30.4 182.49,30.4 181.33,31.55 181.08,31.55 181.07,31.56 180.43,31.56 CS16.2
SATA_CTX_C_DRX_N1: length 5.4
  BOTTOM w0.112: CO5.1 186.81,62.91 186.81,63.23 187.2,63.62 JODD1.5 187.2,64.98 186.83,65.34 186.83,66.33 187.2,66.7 JODD1.6
SATA_CTX_C_DRX_P0: length 13.8
  BOTTOM w0.112: JHDD1.2 189.7,33.64 186.23,30.18 182.4,30.18 181.25,31.33 v4(180.82,31.33) CS15.2
SATA_CTX_C_DRX_P1: length 5.5
  BOTTOM w0.112: JODD1.4 186.2,66.72 186.61,66.31 186.61,65.39 186.2,64.98 JODD1.3 186.2,63.62 186.59,63.23 186.59,62.87 CO4.1
SATA_CTX_DRX_N0: length 73.3
  IN3 w0.135: v1(139.02,60.46) 139.2,60.29 139.2,60.13 139.07,60 137.33,60 136.78,59.45 136.77,59.44 136.77,59.43 135.5,58.16 135.5,58.16 135.49,58.16 135.49,55.39 138.16,52.72 138.16,52.1 139.19,51.08 141.78,51.08 142.25,50.61 142.25,45.13 145.16,42.22 145.16,41.33 148.21,38.29 151.67,38.29 152.72,37.24 162.79,37.24 164.62,35.41 168.36,35.41 169.26,34.51 170.38,34.51 173.07,31.82 174.31,31.82 174.58,32.1 174.58,32.32 v1(174.79,32.53)
  BOTTOM w0.076: UC1.BN4 135.34,60.84 135.58,60.84 135.74,60.77 136.06,60.77 136.09,60.8 136.11,60.81 136.33,60.81 136.43,60.77 136.77,60.77 136.94,60.94 138.22,60.94 138.65,61.37 139,61.37 139.2,61.17 139.2,60.64 v1(139.02,60.46)
  BOTTOM w0.112: v1(174.79,32.53) 174.79,31.85 175.97,30.67 176.86,30.67 177.35,31.15 177.35,31.65 177.81,32.11 178.76,32.11 CS16.1
SATA_CTX_DRX_N1: length 99.5
  IN1 w0.119: v1(174.79,33.21) 174.63,33.36 174.63,35.34 176.32,37.02 176.32,42.72 181.46,47.87 181.46,54.57 186.92,60.03 186.92,60.38 187.02,60.47 v1(187.02,60.84)
  IN3 w0.135: v1(174.79,33.21) 174.56,33.43 174.56,34.02 174.15,34.43 172.64,34.43 171.63,35.43 169.65,35.43 168.75,36.33 165,36.33 163.18,38.16 153.2,38.16 152.05,39.3 148.5,39.3 146.08,41.72 146.08,42.6 143.17,45.52 143.17,51.23 142.4,52 139.57,52 139.09,52.49 139.09,53.1 138.02,54.16 138.02,54.16 136.5,55.69 136.5,57.86 137.5,58.86 139.23,58.86 140.25,59.88 140.25,61.07 v1(140.39,61.21)
  BOTTOM w0.076: v1(140.39,61.21) 140.39,61.22 140.39,61.75 140.21,61.93 138.51,61.93 138.11,61.53 136.48,61.53 136.14,61.2 UC1.BN2
  BOTTOM w0.112: v1(187.02,60.84) 186.83,61.02 186.83,61.18 CO5.2
SATA_CTX_DRX_P0: length 73.3
  IN3 w0.135: v1(174.2,32.53) 174.34,32.39 174.34,32.2 174.21,32.06 173.17,32.06 170.48,34.75 169.36,34.75 168.46,35.65 164.72,35.65 162.89,37.48 152.82,37.48 151.77,38.53 148.31,38.53 145.4,41.43 145.4,42.32 142.49,45.23 142.49,50.71 141.88,51.32 139.29,51.32 138.41,52.2 138.41,52.82 135.74,55.49 135.74,58.06 137.43,59.75 139.17,59.75 139.44,60.03 139.44,60.32 139.6,60.47 139.6,60.49 v1(139.61,60.49)
  BOTTOM w0.076: UC1.BN3 135.25,61.08 135.27,61.06 135.38,61.01 135.62,61.01 135.77,60.94 135.99,60.94 136.08,60.97 136.36,60.97 136.46,60.94 136.7,60.94 136.87,61.11 138.15,61.11 138.58,61.54 139.07,61.54 139.37,61.24 139.37,60.97 139.44,60.89 139.65,60.89 139.81,60.73 139.81,60.61 139.69,60.49 v1(139.61,60.49)
  BOTTOM w0.112: CS15.1 178.86,31.41 178.38,31.89 177.91,31.89 177.57,31.56 177.57,31.06 176.95,30.44 175.88,30.44 174.57,31.76 174.57,32.16 v1(174.2,32.53)
SATA_CTX_DRX_P1: length 99.5
  IN1 w0.119: v1(186.43,60.84) 186.43,60.49 186.52,60.41 186.59,60.41 186.71,60.29 186.71,60.12 181.25,54.66 181.25,47.96 176.1,42.82 176.1,37.12 174.41,35.43 174.41,33.42 v1(174.2,33.21)
  IN3 w0.135: v1(174.2,33.21) 174.32,33.32 174.32,33.92 174.05,34.19 172.54,34.19 171.53,35.19 169.55,35.19 168.65,36.09 164.9,36.09 163.08,37.92 153.1,37.92 151.95,39.06 148.4,39.06 145.84,41.62 145.84,42.5 142.93,45.42 142.93,51.13 142.3,51.76 139.47,51.76 138.85,52.39 138.85,53 136.69,55.16 136.69,55.16 136.26,55.59 136.26,57.96 136.77,58.47 136.77,58.48 137.4,59.1 139.13,59.1 140,59.98 140,61.02 v1(139.81,61.21)
  BOTTOM w0.076: v1(139.81,61.21) 139.75,61.28 139.75,61.43 139.82,61.5 140.15,61.5 140.23,61.58 140.23,61.68 140.14,61.77 139.59,61.77 139.53,61.7 139.53,61.62 139.45,61.54 139.29,61.54 139.07,61.77 138.58,61.77 138.18,61.37 138.01,61.37 137.91,61.27 137.7,61.27 137.61,61.37 137.31,61.37 137.22,61.27 136.97,61.27 136.87,61.37 136.62,61.37 136.55,61.29 UC1.BN1
  BOTTOM w0.112: CO4.2 186.61,61.18 186.61,61.02 v1(186.43,60.84)
SATA_LED#: length 223.9
  TOP w0.112: v1(51.22,39.5) 50.46,38.74 40.19,38.74 v2(39.71,38.26) 38.58,37.13 35.37,37.13 33.69,35.45 RS34.2
  IN1 w0.119: v1(32.85,108.14) 33.02,108.3 33.02,113.14 31.98,114.17 31.98,125.94 v1(28.95,128.96)
  IN2 w0.124: v1(32.85,108.14) 37.84,108.14 40.61,105.36 40.61,94.76 42.59,92.78 42.59,86.53 43.37,85.75 43.37,84.63 42.6,83.86 42.6,75.97 43,75.57 43,68.95 43.68,68.27 43.68,63.44 47.87,59.25 47.87,56.26 49.41,54.72 49.41,46.3 48.79,45.68 48.79,41.93 v1(51.22,39.5) 51.22,39.26 52.71,37.77 57.45,37.77 60.61,34.62 67.57,34.62 67.88,34.3 80.67,34.3 81.1,34.73 91.47,34.73 91.48,34.73 117.52,34.73 119.37,36.58 120.07,36.58 120.47,36.18 130.48,36.18 133.19,38.89 v1(133.19,40.6)
  BOTTOM w0.076: 134.09,42.5 134.09,42.96 133.59,43.46 133.59,45.7 132.48,46.81 132.48,47.03 132.42,47.09 132.42,47.51 133.02,48.1 133.02,48.11 133.06,48.23 133.06,48.41 133.02,48.52 133.02,48.75 UC1.CN7
  BOTTOM w0.112: 134.09,42.5 134.09,41.71 133.55,41.17 133.55,40.96 v1(133.19,40.6) 133.02,40.6 132.74,40.32 RC127.1 ; Q16.2 v1(28.95,128.96)
SATA_LED#_R: length 7.9
  TOP w0.112: v1(27.42,127.19) 28.1,127.87 28.1,128.76 v1(28.95,129.61)
  BOTTOM w0.112: v1(28.95,129.61) Q16.3 ; R30.2 v1(27.42,127.19) v2(26.93,127.67) 25.46,129.14 Q3.3
SATA_ODD_DA#: length 7.9
  BOTTOM w0.112: JODD1.24 JODD1.23 196.2,63.86 196.5,63.56 199.3,63.56 TP55.1
SATA_ODD_PRSNT#: length 105.2
  TOP w0.112: v1(160.64,36.58) 159.61,35.56 155.17,35.56 152.88,33.27 v2(150.86,33.27) 146.89,33.27 144.91,35.24 142.7,35.24 141.52,36.43 141.52,40.44 141.04,40.92 140.76,41.58 140.34,42.21 139.81,42.74 139.19,43.16 138.49,43.44 137.76,43.59 137.01,43.59 136.27,43.44 135.17,42.99 134.27,42.1 133.54,42.1 133.21,42.43 132.97,42.43 v1(132.94,42.46)
  IN1 w0.119: v1(192.49,62.81) 191.92,62.81 191.03,61.91 184.82,61.91 184.62,61.71 184.62,59.24 184.01,58.62 181.26,58.62 180.72,58.08 180.72,55.4 180.47,55.14 180.47,50.73 179.17,49.43 179.17,47.2 178.51,46.54 177.83,46.54 177.59,46.79 176.68,46.79 176.35,46.46 176.35,44.38 172.34,40.37 172.34,37.11 170.47,35.24 161.98,35.24 v1(160.64,36.58)
  BOTTOM w0.076: 132.28,45.75 131.95,46.07 131.95,46.51 131.96,46.52 131.96,46.82 131.9,46.88 131.9,47.6 131.72,47.79 131.72,48.11 131.86,48.51 131.86,49.25 131.59,49.52 131.51,49.52 131.1,49.94 UC1.CM10
  BOTTOM w0.112: v1(132.94,42.46) 132.85,42.55 132.85,42.65 132.84,42.66 132.84,44.35 132.52,44.67 132.52,45.16 132.37,45.32 132.37,45.66 132.28,45.75 ; RO1.1 192.18,62.49 v1(192.49,62.81) 192.63,62.94 192.63,63.18 192.2,63.61 JODD1.15 JODD1.16
SCLK_CPU: length 2
  BOTTOM w0.112: PUZ01.34 176.83,59.64 177.49,60.31 PRZ46.1
SD_RCOMP: length 3.3
  TOP w0.112: v2(116.51,50.05) 116.12,50.05 v1(115.65,50.52)
  TOP w0.254: v1(115.65,50.52) 115.72,50.52 RC54.2
  BOTTOM w0.254: UC1.CM34 v1(115.65,50.52) UC1.CK33
SD_READ_MODE: length 167.1
  TOP w0.112: v1(95.38,36.54) 95.38,36.54 v2(95.79,36.13)
  IN2 w0.124: v1(95.38,36.54) 95.84,36.08 114.4,36.08 117.5,39.17 120.04,39.17 121.04,40.17 125.34,40.17 126.08,39.43 129.73,39.43 130.57,40.28 131,40.28 131.42,40.69 131.42,41.64 131.78,42.01 131.78,43.23 132.39,43.84 133.55,43.84 134.25,44.54 134.61,44.54 135.78,43.37 139.92,43.37 144.55,38.74 146.94,38.74 147.22,38.45 152.26,38.45 153.14,37.57 165.62,37.57 167.41,35.78 171.37,35.78 173.05,37.46 179.92,37.46 180.29,37.83 189.93,37.83 190.3,37.46 190.58,37.46 191.01,37.89 196.01,37.89 197.46,39.34 204.51,39.34 204.63,39.21 v1(204.63,38.92)
  BOTTOM w0.076: UC1.CA30 118.21,55.74 117.77,56.18 113.69,56.18 113.45,55.94 112.12,55.94 RC115.2 111.74,55.54
  BOTTOM w0.112: v1(95.38,36.54) 95.38,36.73 97.44,38.79 97.57,38.79 101.54,42.77 101.54,47.84 103.63,49.93 106.74,49.93 107.73,50.91 107.73,54.02 108.25,54.54 109.25,54.54 109.85,55.13 111.33,55.13 111.74,55.54 ; JIOB1.1 213.2,37.08 212.38,37.9 211.75,37.9 210.44,39.21 207.59,39.21 207.3,38.92 v1(204.63,38.92)
SDIO_CPU: length 2.5
  BOTTOM w0.112: PRZ48.1 175.92,60.94 176.34,60.52 176.34,60.14 176.03,59.83 PUZ01.32
SEL: length 10.8
  TOP w0.112: v1(22.77,117.03) 23.13,116.66 QT1.3 23.99,116.66 24.15,116.82 v2(24.38,116.82) 25.31,116.82 RT12.2 ; UT2.16 v1(24.99,122.93)
  IN1 w0.119: v1(22.77,117.03) 22.77,120.71 v1(24.99,122.93)
SIO_EXT_WAKE#: length 135.3
  TOP w0.112: v1(44.54,73.99) 44.53,73.98 42.45,73.98 42.22,74.21 UE1.116
  IN2 w0.124: v1(129.05,47.09) 128.92,47.09 127.11,45.28 122.84,45.28 122.27,45.85 122.27,46.3 121.92,46.65 121.2,46.65 120.31,45.76 118.93,45.76 118.65,46.03 118.65,47.01 118.14,47.52 117.83,47.52 116.78,46.46 115.43,46.46 113.71,44.73 111.22,44.73 107.94,41.45 99.23,41.45 96.84,39.06 94.89,39.06 94.75,39.2 85.22,39.2 84.74,39.68 81.21,39.68 78.82,37.29 76.05,37.29 75.76,37.58 72.12,37.58 71.33,36.8 68.74,36.8 68.55,36.98 61.63,36.98 58.22,40.39 56.09,40.39 53.63,42.85 53.63,45.73 51.51,47.85 51.51,55.68 49.94,57.26 49.94,62.17 49.42,62.68 49.42,63.9 45.25,68.07 45.25,72.19 44.54,72.9 v1(44.54,73.99)
  BOTTOM w0.076: RC113.2 v2(129.62,45.7) 129.62,46.51 v1(129.05,47.09) 129.4,47.45 129.4,47.81 129.37,47.84 129.37,48.95 UC1.CN12
SIO_PWRBTN#: length 105.1
  TOP w0.112: v1(119.24,58) 118.82,57.59 116.07,57.59 115.88,57.77 114.56,57.77 113.81,57.02 110.87,57.02 110.06,56.21 v2(109.57,56.21) v1(108.56,56.21) ; v1(52.69,76.39) 52.64,76.44 52.64,76.49 52.12,77.01 UE1.52
  IN1 w0.119: v1(102.65,51.3) 102.65,51.75 107.11,56.21 v1(108.56,56.21)
  IN2 w0.124: v1(102.65,51.3) 102.65,50.6 100.45,48.4 89.49,48.4 85.59,44.51 78.17,44.51 77.19,43.53 74.51,43.53 73.23,42.26 70.85,42.26 70.07,43.03 63.91,43.03 63.19,43.75 61.93,43.75 61.37,44.31 60.83,44.31 55.33,49.81 55.33,68.02 53.25,70.1 53.25,75.84 v1(52.69,76.39)
  BOTTOM w0.076: RC98.2 108.54,56.22 v1(108.56,56.21)
  BOTTOM w0.089: v1(119.24,58) UC1.BU28
SIO_SLP_A#: length 12.1
  TOP w0.112: v1(112.56,58.22) 110.38,58.22 110.38,58.22 110.06,58.22 110.05,58.22 109.93,58.22 109.92,58.23 108.43,58.23 106.95,56.75 104.92,56.75 104.65,56.48 103.19,56.48 TP23.1
  BOTTOM w0.102: v1(112.56,58.22) 112.98,57.81 113.34,57.81 113.91,58.37 UC1.BU37
SIO_SLP_LAN#: length 1.2
  TOP w0.112: TP21.1 117.33,58.8 v1(117.33,58.91)
  BOTTOM w0.089: UC1.BT31 v1(117.33,58.91)
SIO_SLP_S0#: length 5.6
  BOTTOM w0.102: TP16.1 108.81,63.24 110,63.24 110.36,63.59 113.73,63.59 UC1.BJ37
SIO_SLP_S3#: length 128.6
  TOP w0.112: v1(44.1,35.62) 44.1,35.36 43.6,34.86 42.96,34.86 42.21,34.1 42.21,32.94 42.58,32.57 46.64,32.57 47.06,32.98 47.06,33.25 50.4,36.59 54.68,36.59 57.2,39.11 66.07,39.11 66.96,40 73.36,40 73.39,40.03 74.31,40.03 76.68,42.4 v1(76.68,42.79) ; v1(98.07,47.48) 97.65,47.91 RC144.1 97.53,48.56 DZ4.1 98.37,50.43 98.76,50.43 98.92,50.58 RC10.2 98.9,50.97 UC9.1 96.82,50.97 96.3,51.49 95.03,51.49 94.83,51.29 RZ2.1 93.32,51.29 v1(93.25,51.23) 93.18,51.15 TP17.1
  TOP w0.203: UZ3.3 37.27,58.43 37.23,58.47 36.74,58.47 36.5,58.23 v1(36.5,58.01) 36.29,57.8 CZ41.1 37.15,57.48 37.31,57.63 UZ3.5
  IN1 w0.119: v1(98.07,47.48) 98.07,48.6 101.48,52.01 102.59,52.01 107.38,56.79 111.76,56.79 v1(113.19,58.22)
  IN3 w0.135: v1(36.5,58.01) 37.27,57.24 37.27,44.03 40.1,41.2 40.1,37.74 42.63,35.2 43.59,35.2 44.01,35.62 v1(44.1,35.62)
  BOTTOM w0.076: UC1.BU36 114.51,58.37 114.03,58.64 113.87,58.64 113.72,58.6 113.61,58.49 113.61,58.34
  BOTTOM w0.102: 113.61,58.34 113.49,58.22 v1(113.19,58.22)
  BOTTOM w0.112: v1(76.68,42.79) 76.93,42.54 81.5,42.54 82.01,43.04 82.01,44.94 88.3,51.23 v1(93.25,51.23)
SIO_SLP_S4#: length 129.9
  TOP w0.112: v1(131.78,107.88) 131.4,107.5 121.07,107.5 114.58,113.99 103.36,113.99 102.24,112.87 88.65,112.87 87.54,113.98 78.9,113.98 77.93,113.01 77.93,108.56 77.69,108.33 DZ7.1 ; TP18.1 124.84,95.11 v1(124.89,95.05)
  IN3 w0.089: 119.98,58.03 120.91,58.96 120.91,60.72
  IN3 w0.135: v1(119.87,58) 119.95,58 119.98,58.03 ; 120.91,60.72 120.91,60.87 120.37,61.41 120.37,85.34 121.64,86.61 124.02,86.61 124.75,87.33 124.75,93.98 124.89,94.11 v1(124.89,95.05)
  BOTTOM w0.089: v1(119.87,58) UC1.BU27
  BOTTOM w0.112: v1(124.89,95.05) 124.89,95.7 126.08,96.9 126.08,97.72 132.88,104.52 132.88,105.75 RC11.2 132.52,107.15 v1(131.78,107.88) RZ1.1 131.17,108.19 DZ5.1 132.06,109.08 CC76.1
SIO_SLP_S5#: length 92.1
  TOP w0.112: PQB29.2 179.65,31.97 v2(178.5,30.82) 176.44,28.76 174.47,28.76 v1(173.88,28.17)
  IN3 w0.089: 131.1,52.2 131.1,52.51 130.35,53.26 130.35,54.53 129.7,55.18 129.7,55.56 128.69,56.57 128.69,60.13 127.92,60.89 123.86,60.89 122.72,59.75 122.72,57.97 122.18,57.43 120.44,57.43 120.41,57.46 117.89,57.46 117.6,57.75 117.6,58.15 117.82,58.37 118.03,58.37 118.58,58.91 v1(118.6,58.91)
  IN3 w0.135: v1(173.88,28.17) 172.25,28.17 170.29,30.13 165.67,30.13 164.75,31.05 164.75,31.94 164.5,32.19 163.1,32.19 162.59,32.71 148.24,32.71 144.76,36.19 144.76,37.2 143.84,38.12 142.26,38.12 141.72,38.67 141.72,40.86 138.85,43.72 138.85,46.33 137.79,47.39 137.09,47.39 135.61,48.87 134.66,48.87 133.89,49.63 131.75,49.63 131.09,50.29 131.09,50.62 131.14,50.67 131.14,52.16 131.1,52.2
  BOTTOM w0.089: UC1.BT29 v1(118.6,58.91)
SIO_SLP_SUS#: length 1.7
  TOP w0.112: v1(118.6,58) 119.08,58.48 TP19.1
  BOTTOM w0.089: v1(118.6,58) UC1.BU29
SIO_SLP_WLAN#: length 1.1
  TOP w0.112: TP22.1 118.23,58.65 v1(117.97,58.91)
  BOTTOM w0.089: UC1.BT30 v1(117.97,58.91)
SKTOCC#: length 3.9
  BOTTOM w0.102: UC1.E1 137.37,90.4
  BOTTOM w0.112: 137.37,90.4 139.29,92.32 RC173.1
SLEEVE: length 16.2
  TOP w0.127: v1(17.88,14.16) 17.88,13.3 v2(17.65,13.08)
  IN1 w1.016: 18.96,14.47 19.85,14.47 20.54,13.77 21.75,13.77 22.51,14.54 22.51,15.87 24.16,17.52 31.4,17.52
  vias: v1(17.88,14.79) v1(32.19,17) v1(32.19,16.42)
SLEEVE_R: length 18
  TOP w0.127: v2(17.66,15.46) 18,15.81 CA40.1
  IN1 w1.016: 18.51,17.52 18.07,17.08 15.76,17.08 14,18.83 6.46,18.83 5.03,17.4 JHP1.3
  vias: v1(19.21,18.66) v1(19.21,18.03)
SM_RCOMP0: length 1.8
  TOP w0.381: RC17.1 119.43,61.41 119.24,61.22 v1(119.24,60.74)
  BOTTOM w0.305: v1(119.24,60.74) UC1.BN28
SM_RCOMP1: length 1.8
  TOP w0.381: v1(119.87,60.74) 119.87,60.97 120.14,61.23 RC18.1
  BOTTOM w0.305: v1(119.87,60.74) UC1.BN27
SM_RCOMP2: length 2.2
  TOP w0.381: RC20.1 117.67,61.81 118.2,61.27 118.4,61.27 118.6,61.07 v1(118.6,60.74)
  BOTTOM w0.305: v1(118.6,60.74) UC1.BN29
SML0_SMBCLK: length 8.9
  TOP w0.112: RC33.2 127.37,44.79 127.37,45.51 v4(128.1,46.24) 128.41,46.55 128.41,48.28 128.12,48.57 128.12,49.89 128.41,50.17 128.41,51.84 128.3,51.95 v1(128.08,51.95)
  BOTTOM w0.102: UC1.CH14 128.5,51.95 v1(128.08,51.95)
SML0_SMBDATA: length 9.9
  TOP w0.112: RC34.2 127.72,44.79 127.72,44.8 127.61,44.92 127.61,45.41 128.65,46.46 128.65,48.38 128.36,48.67 128.36,49.79 128.65,50.08 128.65,51.96 v1(128.08,52.53)
  BOTTOM w0.102: UC1.CF15 127.52,53.09 v1(128.08,52.53)
SML1_SMBCLK: length 382
  TOP w0.112: RE11.1 41.89,64.83 41.89,65.65 v1(42.02,65.78) 41.83,65.96 41.83,66.37 41.67,66.53 41.67,66.84 41.75,66.92 UE1.12 ; Q11.3 176.64,66.3 175.97,66.97 175.81,66.97 175.77,66.92 174.71,66.92 174.41,67.22 174.41,74.31 174.69,74.59 v1(174.69,74.84) ; QV1.6 123.66,121.95 v1(123.42,121.71)
  IN1 w0.119: v1(53.92,108.08) 53.78,108.22 53.45,108.22 53.07,108.59 53.07,110.5 57.05,114.48 57.05,116 62.89,121.84 70.68,121.84 72.72,123.88 76.36,123.88 77,123.25 78.87,123.25 82.68,119.43 88.59,119.43 89.89,118.14 94.59,118.14 94.81,118.36 112.11,118.36 114.97,115.5 124.49,115.5 125.26,116.26 125.26,117.66 123.1,119.82 123.1,120.2 123.35,120.45 123.35,121.64 v1(123.42,121.71) 124.05,121.09 124.65,121.09 125.13,121.57 125.13,122.61 125.64,123.12 126.83,123.12 131.48,118.47 131.48,112.71 134.83,109.36 142.52,109.36 146.09,105.78 159.11,105.78 171.28,93.61 171.28,88.68 171.51,88.45 171.51,77.25 174.29,74.47 174.52,74.47 174.69,74.63 v1(174.69,74.84)
  IN3 w0.135: v1(128.14,45.4) 128.3,45.23 128.3,44.51 128.75,44.06 128.75,40.64 127.17,39.06 126.71,39.06 125.06,37.42 119.23,37.42 117.18,35.36 95.93,35.36 88.25,27.69 69.04,27.69 68.34,28.39 61.88,28.39 58.45,31.82 57.83,31.82 56.34,33.31 54.94,33.31 54.26,33.99 49.82,33.99 43.29,40.53 43.29,46.4 42.33,47.35 42.33,52.85 45.38,55.89 45.38,61.27 43.85,62.8 43.85,64.67 43.44,65.08 42.07,65.08 41.82,65.33 41.82,65.59 v1(42.02,65.78) 41.82,65.98 41.82,66.73 40.6,67.95 40.6,71.19 41.96,72.55 42.33,72.55 44.1,74.33 44.1,76.13 45.5,77.53 45.5,80.96 46.01,81.47 46.01,84.13 46.77,84.89 46.77,93.4 48.05,94.68 48.05,97.96 46.26,99.74 46.26,105.21 49.29,108.24 53.75,108.24 v1(53.92,108.08)
  BOTTOM w0.076: RC196.2 127.69,44.56 127.69,44.74 127.89,44.93 128.04,44.93 128.27,45.16 128.27,45.26 v1(128.14,45.4) 128.13,45.41 128.13,47.63 127.98,47.78 127.98,48.11 128.02,48.23 128.02,48.41 127.98,48.52 127.98,48.76 127.77,48.97 UC1.CN15
SML1_SMBDATA: length 382.6
  TOP w0.112: QV1.3 124.96,120.41 v1(124.62,120.07) ; RE10.1 41.65,64.74 41.65,65.56 v1(41.43,65.78) 41.6,65.94 41.6,66.27 41.43,66.43 41.43,66.83 41.35,66.91 UE1.11 ; Q11.6 175.86,67.43 175.83,67.28 175.68,67.18 175.67,67.16 174.81,67.16 174.64,67.32 174.64,74.21 174.85,74.42 v1(175.1,74.42)
  IN1 w0.119: v1(175.1,74.42) 174.82,74.42 174.63,74.23 174.18,74.23 171.26,77.15 171.26,88.35 171.03,88.58 171.03,93.51 159.01,105.53 145.99,105.53 142.41,109.11 134.73,109.11 131.23,112.61 131.23,118.37 126.73,122.88 125.74,122.88 125.38,122.51 125.38,121.46 124.62,120.71 v1(124.62,120.07) 124.11,120.07 123.8,120.39 123.63,120.39 123.34,120.1 123.34,119.92 125.5,117.76 125.5,116.16 124.59,115.25 114.87,115.25 112.01,118.11 94.91,118.11 94.69,117.89 89.78,117.89 88.49,119.19 82.58,119.19 78.77,123 76.89,123 76.26,123.64 72.82,123.64 70.78,121.6 62.99,121.6 57.29,115.9 57.29,114.37 53.31,110.39 53.31,108.7 53.55,108.46 53.72,108.46 v1(53.92,108.66)
  IN3 w0.135: v1(128.72,45.4) 128.57,45.24 128.57,44.62 129.01,44.17 129.01,40.53 127.28,38.8 126.82,38.8 125.17,37.16 119.34,37.16 117.29,35.1 96.04,35.1 88.36,27.43 68.93,27.43 68.23,28.13 61.77,28.13 58.34,31.55 57.72,31.55 56.23,33.05 54.83,33.05 54.15,33.73 49.71,33.73 43.02,40.42 43.02,46.29 42.07,47.24 42.07,52.95 45.12,56 45.12,61.16 43.59,62.69 43.59,64.56 43.33,64.82 41.96,64.82 41.56,65.22 41.56,65.65 v1(41.43,65.78) 41.56,65.9 41.56,66.63 40.34,67.84 40.34,71.3 41.85,72.81 42.22,72.81 43.84,74.44 43.84,76.24 45.24,77.64 45.24,81.07 45.75,81.57 45.75,84.24 46.51,85 46.51,93.51 47.79,94.79 47.79,97.85 46,99.63 46,105.32 49.18,108.5 53.75,108.5 v1(53.92,108.66)
  BOTTOM w0.076: RC197.2 127.86,44.45 127.86,44.67 127.95,44.76 128.11,44.76 128.72,45.37 v1(128.72,45.4) 128.51,45.61 128.43,45.61 128.29,45.75 128.29,47.7 128.14,47.85 128.14,48.08 128.18,48.2 128.18,48.44 128.14,48.55 128.14,48.86 128.01,49 128.01,49.12 127.75,49.37 UC1.CM15
SN_1.2V: length 1
  TOP w0.112: 52.07,28.44 v2(53.06,28.44)
SN_1.05V: length 2.9
  TOP w0.112: PCH13.1 158.34,42.87 v2(158.52,42.69)
  TOP w0.635: PCH13.1 PRH07.2
SN_3V: length 2.2
  TOP w0.112: PR305.2 v2(23.95,41.69)
SN_5V: length 1.5
  TOP w0.112: 21.24,101.05 22.01,101.05 v2(22.54,100.52)
SNB_VCCSA: length 3.1
  TOP w0.112: v2(162.09,55.76) PRA02.2
  TOP w0.635: PRA02.2 PCA09.1
SNUB1_CHG: length 3.4
  TOP w0.112: v2(188.49,41.14) PRB40.2
  TOP w0.635: PRB40.2 PCB29.1
SNUB_+1.35VGPU: length 1.3
  TOP w0.112: PRW07.2 v2(151.8,109.77)
SOC_XDP_TDI: length 14.2
  TOP w0.112: RC151.2 138.71,83.43 137.77,84.37 135.9,84.37 134.86,83.34 133.88,83.34 v1(133.51,83.71) 133.03,83.23 TPC5.1
  BOTTOM w0.102: UC1.U5 v1(133.51,83.71) UC1.U6
SOC_XDP_TDO: length 14
  TOP w0.112: RC152.2 143.77,81.91 143.23,82.45 138.3,82.45 137.36,83.39 136.3,83.39 134.78,81.86 v1(133.43,81.86) 133.04,81.47 TPC1.1
  BOTTOM w0.102: UC1.Y5 133.43,81.81 v1(133.43,81.86) 133.85,82.28 UC1.W5
SOC_XDP_TMS: length 12.3
  TOP w0.112: v1(134.11,84.64) 134.11,84.73 TPC4.1 136.22,85.62 136.98,84.86 137.98,84.86 138.64,84.2 RC150.2
  BOTTOM w0.102: UC1.T5 v1(134.11,84.64) UC1.P5
SOC_XDP_TRST#: length 2.4
  TOP w0.112: TPC6.1 134.3,80.49 133.97,80.49 v1(133.52,80.94)
  BOTTOM w0.102: UC1.AB6 133.2,80.62 v1(133.52,80.94) 133.2,81.26 UC1.Y6
SPI_CLK_ROM: length 14.1
  IN3 w0.135: v1(112.81,30) 112.81,30.21 112.95,30.35 115.06,30.35 115.22,30.19 116.84,30.19 119.13,32.48 119.45,32.48 v1(119.48,32.45)
  BOTTOM w0.112: UC3.6 119.64,34.86 119.32,35.17 RC45.2 119.11,33.83 119.48,33.46 v1(119.48,32.45) ; v1(112.81,30) 112.81,30.16 113.19,30.54 RC40.1
SPI_CLK_ROM2: length 28.9
  IN3 w0.135: v1(112.23,29.89) 112.23,29.41 113.64,28 117.86,28 118.53,28.67 118.53,29.4 119.08,29.95 132.32,29.95 133.13,29.14 v1(133.13,28)
  BOTTOM w0.112: RC178.1 112.23,30.64 v1(112.23,29.89) ; UC11.6 134.78,25.97 133.77,26.98 133.38,26.98 133.13,27.23 v1(133.13,28)
SPI_CLK_TPM: length 41.3
  TOP w0.112: v1(87.54,29.01) 87.95,29.43 88.65,29.43 88.93,29.14 v2(91.79,29.14) 97.47,29.14 v1(97.85,28.76) ; v1(83.61,36.13) 83.61,36.14 83.83,36.37 UX1.19
  BOTTOM w0.112: RX9.2 113.95,30.48 112.74,29.27 109,29.27 108.62,29.65 108.62,29.93 107.75,30.79 106.08,30.79 104.3,29.01 98.11,29.01 v1(97.85,28.76) ; v1(87.54,29.01) 84.74,29.01 83.73,30.02 83.73,31.31 84.37,31.95 84.37,35.35 84.2,35.53 83.6,36.13 83.6,36.13 v1(83.61,36.13)
SPI_D0_ROM: length 24.3
  TOP w0.112: v1(108.08,29.89) 108.08,30.62 RC42.1
  IN3 w0.135: v1(108.08,29.89) 108.08,31.72 108.29,31.94 108.57,31.94 108.71,31.8 108.71,30.93 108.84,30.79 109.11,30.79 109.24,30.93 109.24,31.8 109.38,31.94 110.11,31.94 110.23,32.06 115.35,32.06 115.7,32.41 116.21,32.41 119.11,35.31 122.51,35.31 v1(122.97,34.86)
  BOTTOM w0.112: UC3.5 122.65,33.59 122.97,33.9 v1(122.97,34.86)
SPI_D0_ROM2: length 37.5
  TOP w0.112: v1(107.46,29.89) 107.87,29.47 108.44,29.47 108.68,29.71 108.68,30.22 109.13,30.67 RC180.1
  IN3 w0.135: v1(107.46,29.89) 107.48,29.89 111.12,26.24 127.52,26.24 128.4,27.12 133.64,27.12 135.23,28.71 136.35,28.71 v1(136.4,28.76)
  BOTTOM w0.112: v1(136.4,28.76) 136.4,27.33 136.05,26.98 136.05,25.77
SPI_D0_TPM: length 47.4
  TOP w0.112: UX1.21 83.88,35.37 v1(83.71,35.2) ; RX6.2 109.89,30.47 109.64,30.22 109.64,29.65 109.09,29.11 106.87,29.11 106.08,29.9 106.08,32.77 106.08,32.78 106.08,33.08 106.08,33.19 105.13,34.14 102.31,34.14 100.53,32.36 100.53,29.28 99.98,28.73 99.98,27.78 99.06,26.86 98.59,26.39 86.48,26.39 v2(83.99,28.88) v1(81.57,31.3)
  BOTTOM w0.112: v1(81.57,31.3) 82.2,31.3 83.83,32.93 83.83,35.08 v1(83.71,35.2)
SPI_D1_ROM: length 25.9
  TOP w0.112: RC43.1 112.18,30.42 v1(111.64,29.89)
  IN3 w0.135: v1(130.28,34.22) 130.12,34.38 130.12,34.4 129.87,34.64 127.3,34.64 124.59,31.94 121.57,31.94 120.51,33 118.44,33 116.69,31.25 116.19,31.25 115.8,30.86 112.6,30.86 111.64,29.91 v1(111.64,29.89)
  BOTTOM w0.112: v1(130.28,34.22) 130.28,34.95 129.1,36.13 UC3.2
SPI_D1_ROM2: length 28.8
  TOP w0.112: v1(111.06,29.89) 111.41,30.25 RC179.1
  IN3 w0.135: v1(111.06,29.89) 110.82,30.14 110.82,30.66 111.41,31.25 115.64,31.25 116.03,31.64 116.53,31.64 118.05,33.16 118.28,33.39 120.67,33.39 121.73,32.32 124.37,32.32 127.16,35.12 130.25,35.12 v1(131.14,34.22)
  BOTTOM w0.112: 133.51,33.02 133.51,33.86 133.33,34.04 131.32,34.04 131.14,34.22 v1(131.14,34.22)
SPI_D1_TPM: length 48.9
  TOP w0.112: RX5.2 110.65,30.39 110.6,30.34 110.6,29.8 109.54,28.74 106.72,28.74 105.71,29.75 105.71,32.93 104.87,33.77 102.53,33.77 100.9,32.14 100.9,29.13 100.36,28.59 100.36,27.64 98.74,26.02 86.08,26.02 v2(85.45,26.65) v1(80.81,31.3) ; UX1.24 84.11,33.87 83.87,33.63 83.87,32.93 83.5,32.56 82.42,32.56 81.95,33.03 v1(81.95,33.03)
  BOTTOM w0.112: v1(81.95,33.03) 81.95,32.44 v1(80.81,31.3)
SPI_D2_ROM: length 19.6
  IN3 w0.135: v1(129.69,34.22) 127.42,34.22 124.38,31.17 118.55,31.17 117.05,29.67 114.85,29.67 v1(114.64,29.89)
  BOTTOM w0.112: RC39.2 114.72,30.38 114.64,30.3 v1(114.64,29.89) ; v1(129.69,34.22) 129.7,34.22 129.7,34.48 129.32,34.86 UC3.3
SPI_D2_ROM2: length 24.6
  TOP w0.112: v1(114.03,29.89) 114.03,30.23 114.21,30.41 RC177.2
  IN3 w0.135: v1(133.79,30.79) 133.47,30.47 118.39,30.47 117.21,29.28 114.28,29.28 114.03,29.53 v1(114.03,29.89)
  BOTTOM w0.112: UC11.3 134.78,32.44 133.79,31.45 v1(133.79,30.79)
SPI_D3_ROM: length 22
  IN3 w0.135: v1(123.61,34.86) 123.18,34.43 122.79,34.43 122.3,34.92 119.27,34.92 116.37,32.03 115.86,32.03 115.48,31.64 110.8,31.64 110.43,31.27 110.43,30.21 v1(110.1,29.89)
  BOTTOM w0.112: UC3.7 122.97,36.13 123.61,35.49 v1(123.61,34.86) ; v1(110.1,29.89) 110.52,30.31 111.56,30.31 111.67,30.42 RC41.2
SPI_D3_ROM2: length 30.3
  IN3 w0.135: v1(109.19,29.89) 109.24,29.89 112.12,27.02 127.2,27.02 128.94,28.76 131.78,28.76 v1(132.55,28)
  BOTTOM w0.112: v1(109.19,29.89) 110.14,30.84 RC181.2 ; v1(132.55,28) 132.55,27.12 133.51,26.15 133.51,25.77
SPKR: length 132
  TOP w0.112: DA3.2 v1(22.46,24.77)
  IN2 w0.124: v1(65.45,26.22) 65.1,26.57 61.15,26.57 59.99,27.73 58.16,27.73 57.02,28.88 57.02,29.82 54.68,32.16 47.86,32.16 v1(47.48,32.54)
  IN3 w0.135: v1(22.46,24.77) 25.76,24.77 26.73,25.74 26.73,31.86 28.48,33.61 30.94,33.61 31.19,33.86 33.01,33.86 33.56,34.41 41.33,34.41 41.63,34.11 46.37,34.11 47.48,33 v1(47.48,32.54)
  BOTTOM w0.076: UC1.CF35 114.9,53.66 114.34,53.66 114.22,53.69 114.07,53.77 113.67,53.77 113.42,53.53
  BOTTOM w0.102: 113.42,53.53 113.28,53.53 110.02,50.26 110.02,49.64 RC57.2
  BOTTOM w0.112: RC57.2 109.58,48.32 v2(108.81,47.55) 107.44,46.17 107.44,45.06 106.72,44.35 106.72,43.42 105.02,41.72 105.02,33.11 105.84,32.29 105.84,31.43 104.89,30.49 102.02,30.49 100.23,32.27 98.92,32.27 97.95,33.25 96.13,33.25 95.42,32.53 95.42,28.08 92.8,25.47 66.21,25.47 v1(65.45,26.22)
SSD_DEVSLP: length 130.8
  TOP w0.112: v1(53.44,39.49) 53.03,39.08 52.03,39.08 51.72,39.39 51.72,39.75 51.53,39.94 50.52,39.94 49.53,38.95 39.96,38.95 38.45,37.44 v2(37.63,37.44) 35.38,37.44 31.29,33.34 31.29,31.93 31.33,31.89 v1(31.33,31.75)
  IN2 w0.124: v1(133.43,43) 132.76,43 132.46,42.7 132.46,41.73 132.09,41.36 132.09,39.04 130.61,37.55 128.13,37.55 127.29,38.4 126.22,38.4 125.38,37.55 121.86,37.55 121.43,37.98 119.21,37.98 117.76,36.53 115.5,36.53 114.58,35.61 95.43,35.61 93.88,37.16 91.6,37.16 91.04,37.72 84.55,37.72 84.07,38.2 81.83,38.2 78.81,35.18 68.25,35.18 67.94,35.5 60.97,35.5 57.82,38.65 54.28,38.65 v1(53.44,39.49)
  BOTTOM w0.076: UC1.CM8 132.23,49.69 132.48,49.44 132.48,48.7
  BOTTOM w0.102: 132.37,46.67 132.31,46.73 132.31,46.96 132.25,47.02 132.25,47.58 132.41,47.75 132.41,48.63 132.48,48.7
  BOTTOM w0.112: v1(31.33,31.75) 30.7,31.12 30.7,27.81 30.13,27.23 JSSD1.38 ; 132.37,46.67 133.41,45.62 133.41,43.01 v1(133.43,43)
SSD_SCP#: length 257.2
  TOP w0.112: RE60.1 46.31,92.73 v2(45.35,91.77) 42.24,88.65 39.66,88.65 39.31,88.31 v1(39.09,88.31) ; v1(44.61,69.72) 45.35,68.98 UE1.21 ; RS29.1 v1(168.14,28.5)
  IN1 w0.119: v1(44.61,69.72) 44.22,70.11 44.22,71.31 43.09,72.45 42.07,72.45 41.06,73.46 v1(40.23,73.46)
  IN2 w0.124: v1(40.23,73.46) 39.28,74.42 39.28,83.5 38.77,84.01 38.77,87.99 v1(39.09,88.31) ; v1(36.37,61.79) 36.75,61.41 38.62,61.41 39.01,61.02 40.74,61.02 41.13,60.63 42.01,60.63 43.77,58.87 44.7,57.94 44.7,54.91 43.77,53.98 43.77,38.88 47.09,35.57 47.09,32.25 47.4,31.93 54.59,31.93 56.8,29.73 56.8,28.78 58.07,27.51 59.9,27.51 61.06,26.35 64.77,26.35 65.67,25.45 100.23,25.45 101.51,26.73 123.81,26.73 124.32,27.24 133.89,27.24 138.46,31.81 144.56,31.81 147.71,28.66 148.92,28.66 150.29,27.29 159.32,27.29 159.69,27.65 165.93,27.65 167.34,27.67 v1(168.14,28.5)
  BOTTOM w0.112: RS2.2 41.18,25.04 41.18,30.79 42.12,31.73 42.12,37.66 37.36,42.43 37.36,54.49 37.72,54.85 37.72,60.75 37.26,61.21 36.95,61.21 v1(36.37,61.79) 37.97,63.39 37.97,64.32 37.26,65.04 37.26,65.68 39.71,68.13 39.71,72.95 v1(40.23,73.46)
SUSCLK: length 13.2
  TOP w0.112: RC80.1 RC79.1 107.24,56.26 108.71,57.73 v2(109.33,57.73) 113.52,57.73 114.27,58.48 116.02,58.48 116.46,58.91 v1(116.69,58.91)
  BOTTOM w0.076: v1(116.69,58.91) 116.69,58.91 UC1.BT32
SUSCLK_EC: length 129
  TOP w0.112: RE42.2 33.09,67.92 v1(33.77,67.24) ; RC80.2 103.6,55.49 v2(102.83,54.72) 101.45,53.35 101.45,50.59 99.42,48.56 99.42,45.16 v1(99.33,45.07)
  IN1 w0.119: v1(33.77,67.24) 33.77,63.99 35.21,62.54 36.94,62.54 38.9,60.59 38.9,59.24 38.39,58.73 v1(38.39,54.29)
  BOTTOM w0.112: v1(99.33,45.07) 99.26,45.14 99.17,45.14 98.94,44.92 98.94,44.87 98.47,44.39 98.47,42.98 96.21,40.72 94.8,40.72 92.85,38.76 92.58,38.76 92.58,38.76 91.43,38.76 90.02,37.35 90.02,34.92 92.09,32.85 92.09,26.97 91.08,25.96 68.63,25.96 68.34,26.25 64.4,30.19 60.53,30.19 58.48,32.24 58,32.24 54.38,35.86 47.48,35.86 45.96,37.38 43.4,37.38 38.07,42.72 38.07,53.97 v1(38.39,54.29)
SUSCLK_WLAN: length 182.7
  TOP w0.112: v1(98.86,45.42) 98.93,45.49 98.93,48.77 100.96,50.79 100.96,53.55 v2(101.45,54.04) 103.4,55.99 104.86,55.99 105.13,56.26 RC79.2
  IN1 w0.119: v1(61.88,132.9) 61.88,130.91 58.42,127.44 58.42,126.6 56.48,124.66 56.48,123.46 50,116.98 50,115.18 48.21,113.38 v1(48.21,105.72)
  IN3 w0.135: v1(48.21,105.72) 48.29,105.72 52.56,101.46 52.56,97.51 55.27,94.8 55.27,84.75 52.06,81.55 52.06,76.18 52.58,75.66 52.58,73.21 53.25,72.54 53.25,69.4 53.86,68.79 53.86,65.87 54.61,65.12 54.61,64.48 53.83,63.7 53.83,60.41 50.52,57.09 50.52,42.99 52.68,40.83 53.82,40.83 55.37,39.28 57.36,39.28 58.51,38.13 59.28,38.13 60.99,36.41 71.64,36.41 72.29,35.76 77.39,35.76 83.61,41.99 86.04,41.99 89.15,45.1 90.97,45.1 91.49,44.58 93.12,44.58 93.21,44.49 97.93,44.49 v1(98.86,45.42)
  BOTTOM w0.112: v1(61.88,132.9) 62.04,132.74 63.76,132.74 63.91,132.9 JWLAN1.50
SVI2_SVC: length 89
  TOP w0.112: v1(70.21,131.38) 70.39,131.38 70.94,130.83 71.09,130.83 71.22,130.7 PUV01.3
  IN1 w0.119: v1(70.21,131.38) 70.96,130.62 70.96,127.94 71.77,127.13 73.63,127.13 74.96,125.79 75.73,125.79 75.85,125.92 77.38,125.92 78.2,125.09 81.02,125.09 82.25,123.86 82.25,122.02 82.83,121.44 93.35,121.44 95.05,119.74 102.83,119.74 103.92,120.83 103.92,126.23 107.53,129.84 108.44,130.74 v1(108.59,130.74) 108.75,130.58 109.47,130.58 109.81,130.25 109.81,121.38 111.25,119.94 111.99,119.94 114.52,117.41 121.71,117.41 v1(122.23,117.93)
  BOTTOM w0.112: RV45.1 122.27,117.97 v1(122.23,117.93) ; v1(108.59,130.74) 108.59,130.62 107.61,129.65 107.61,128.54 106.9,127.83 106.9,127.49 107.71,126.67 108.52,126.67 RV84.1 109.44,127.11 RV157.2 RV89.2
SVI2_SVD: length 86.2
  TOP w0.112: v1(70.35,130.49) 70.67,130.49 71.26,129.9 PUV01.5
  IN1 w0.119: v1(70.35,130.49) 70.35,130.09 70.74,129.7 70.74,127.84 71.68,126.91 73.53,126.91 74.9,125.53 75.79,125.53 75.92,125.66 77.31,125.66 78.11,124.87 80.93,124.87 82.03,123.77 82.03,121.92 82.74,121.22 93.26,121.22 94.96,119.51 102.92,119.51 104.14,120.74 104.14,126.13 107.75,129.74 108.08,130.07 108.41,130.07 108.42,130.08 v1(108.64,130.08) 108.92,130.36 109.38,130.36 109.59,130.15 109.59,121.29 111.16,119.72 111.9,119.72 114.97,116.64 123.85,116.64 v1(124.11,116.91)
  BOTTOM w0.112: v1(124.11,116.91) 124.68,117.48 RV44.1 ; RV155.2 108.65,130.1 v1(108.64,130.08) 108.64,129.52 108.94,129.22 RV88.2 RV87.1
SVI2_SVT: length 54.6
  TOP w0.112: PUV01.7 70.59,129.1 70.38,129.31 v1(70.35,129.31)
  IN1 w0.119: v1(70.35,129.31) 70.52,129.14 70.52,127.75 71.59,126.68 73.43,126.68 74.84,125.28 75.85,125.28 75.98,125.41 77.25,125.41 78.01,124.65 80.84,124.65 81.81,123.68 81.81,121.83 82.65,120.99 93.17,120.99 94.87,119.29 103.01,119.29 104.36,120.65 104.36,126.04 107.4,129.08 108.48,129.08 109.05,129.65 v1(109.2,129.65)
  BOTTOM w0.112: RV156.2 109.4,129.65 v1(109.2,129.65)
SYS_LED_MASK#: length 19.9
  TOP w0.112: RE95.1 v2(49.83,93.33) 49.86,93.3 49.86,92.43 v1(49.82,92.39) ; v1(49.56,77.53) 49.56,77.91 49.86,78.21 UE1.55
  IN2 w0.124: v1(49.82,92.39) 49.82,90.29 49.18,89.66 49.18,87.43 48.87,87.12 48.87,84.84 49.64,84.07 49.64,77.61 v1(49.56,77.53)
SYS_PWROK: length 139.9
  TOP w0.112: UE1.28 48.15,68.57 45.72,71 43.88,71 v1(43.68,71.2)
  IN2 w0.124: v1(133.16,41.29) 133.16,41.24 132.65,40.72 132.65,38.81 130.35,36.51 120.61,36.51 120.21,36.91 119.24,36.91 117.38,35.06 95.2,35.06 94,36.25 85,36.25 84.36,35.62 83.52,35.62 83.23,35.91 81.81,35.91 80.53,34.63 68.02,34.63 67.71,34.94 60.74,34.94 57.59,38.1 52.86,38.1 51.66,39.3 51.66,39.87 50.49,41.04 50.49,46.63 49.73,47.38 49.73,54.85 48.19,56.39 48.19,59.39 46.25,61.33 46.25,62.65 45.51,63.39 45.51,65 44.01,66.5 44.01,68.4 43.59,68.82 43.59,71.11 v1(43.68,71.2)
  BOTTOM w0.102: UC1.CR10 130.84,47.9 130.84,47.37 131.05,47.16 131.05,46.44 131.91,45.58 131.91,45.35
  BOTTOM w0.112: 131.91,45.35 RE22.1 131.94,44.71 132.34,44.31 132.34,43.4 132.24,43.31 132.24,41.71 CC79.2 v2(132.68,41.13) 133,41.13 v1(133.16,41.29)
SYS_RESET#: length 4.9
  BOTTOM w0.076: UC1.CN10 130.84,48.99 130.7,48.85 130.66,48.73 130.66,48.55 130.7,48.44 130.7,48.2 130.66,48.08 130.66,47.28 130.86,47.08
  BOTTOM w0.112: 130.86,47.08 130.86,46.02 v2(131.15,45.73) RC100.2
SYSPWR_PRES: length 4.6
  TOP w0.112: RE30.1 32.08,73.66 32.09,73.65 RE32.1 33.16,72.75 v2(33.19,72.72) 33.3,72.61 UE1.120
T_CRIT#: length 4.2
  BOTTOM w0.112: 180.29,60.49 180.56,60.49 181.39,59.66 v2(181.73,59.66) ; 180.29,60.49 R55.2 ; 180.29,60.49 180.29,60.88 U3.4
TESTEN: length 6.3
  TOP w0.102: v3(129.93,124.77) 129.93,125.06 129.61,125.37 v1(129.36,125.37) ; 128.53,122.33 128.45,122.25
  TOP w0.112: v3(129.93,124.77) 129.93,124.61 129.56,124.24 129.56,122.6 129.29,122.33 128.53,122.33 ; 128.45,122.25 128.27,122.07 RV18.2 128.17,122.07 RV17.2
  BOTTOM w0.102: UV1.K7 v1(129.36,125.37)
THM_SML1_CLK: length 12.6
  TOP w0.112: v1(177.71,67.15) 177.85,67.29 177.96,67.29 178.12,67.13 178.12,65.81 177.83,65.53 v2(177.52,65.53) 177.14,65.91 177.14,67.31 176.64,67.8 Q11.4 176.64,69.09 R50.2
  BOTTOM w0.112: U3.8 178.8,65.13 178.8,64.84 178.91,64.73 179.23,64.73 179.42,64.91 179.42,66.48 178.58,67.32 177.88,67.32 v1(177.71,67.15)
THM_SML1_DATA: length 15.3
  TOP w0.112: Q11.1 175.34,65.27 R49.2 175.28,64.33 175.8,63.81 176.37,63.81 v2(176.61,64.05) 177.8,65.24 177.85,65.29 177.93,65.29 178.36,65.71 178.36,67.23 178.05,67.53 177.91,67.53 v1(177.71,67.73)
  BOTTOM w0.112: U3.7 178.34,64.67 178.63,64.67 178.81,64.49 179.33,64.49 179.66,64.81 179.66,66.58 178.68,67.56 177.88,67.56 v1(177.71,67.73)
TON_1.2V: length 2
  TOP w0.203: PRM07.2 33.78,27.47 34.72,28.41 PUM01.9
TOUCH_I2C_DET#: length 6.3
  TOP w0.112: v1(119.17,54.34) 118.97,54.14 118.97,52.98 118.28,52.3 v2(118.28,52.05) 118.28,50.81 118.91,50.19 RC209.1 RC208.2
  BOTTOM w0.076: v1(119.17,54.34) 118.86,54.65 UC1.CC29
TOUCH_PAD_INT#: length 7.4
  BOTTOM w0.076: UC1.CB34 115.23,54.9 113,54.9 111.57,53.46 v2(110.91,53.46) 110.16,53.46 RC5.2
  BOTTOM w0.112: DZ1.2 109.97,52.27 RC5.2
TOUCH_PANEL_PD#: length 8.3
  BOTTOM w0.076: 113,54.21 113.11,54.33 113.5,54.33 113.52,54.3 114.89,54.3 115.14,54.55 UC1.CC35
  BOTTOM w0.102: 113,54.21 113,54.15 112.06,53.21 v2(112.06,52.84) 112.06,52.74 110.05,50.73 RC6.2 109.55,50.69 RC14.2
TOUCH_SCREEN_INT#: length 137.8
  TOP w0.112: RC203.2 v2(140.03,50.41) 136.94,50.41 135.15,48.62 v1(135.15,47.56)
  IN1 w0.119: v1(213.22,49.21) 213.3,49.29 214.96,49.29 215.08,49.41 215.08,50.19 215.84,50.95 216.22,50.95 216.61,51.34 217.2,51.34 218.58,49.97 219.62,49.97 220.13,49.46 220.13,38.79 220.59,38.32 220.59,35 v1(219.57,33.97)
  IN3 w0.135: v1(219.57,33.97) 219.57,33.37 218.83,32.63 218.31,32.63 218.03,32.91 212.76,32.91 211.24,31.4 181.38,31.4 178.2,28.21 174.52,28.21 174.08,27.78 172.29,27.78 170.18,29.89 165.57,29.89 164.72,30.74 163.43,30.74 161.71,32.47 148.14,32.47 144.43,36.17 144.43,37.08 144.19,37.32 142.65,37.32 141.48,38.5 141.48,40.73 138.46,43.75 138.46,45.52 137.41,46.58 136.34,46.58 135.36,47.56 v1(135.15,47.56)
  BOTTOM w0.076: v1(135.15,47.56) 135.15,47.73 135.07,47.81 135.07,48.41 134.91,48.57 134.91,48.95 135.24,49.28 UC1.CN3
  BOTTOM w0.112: JEDP1.24 213.01,48.95 213.22,49.16 v1(213.22,49.21)
TOUCH_SCREEN_PD#: length 166.4
  TOP w0.112: v2(211.79,39.02) v1(211.13,39.67) 211.02,39.78 D3.2 211.3,40.43 212.51,41.64 R14.2
  IN2 w0.124: v1(95.03,28.57) 95.03,29.59 97.18,31.74 103.82,31.74 104.43,32.35 106.11,32.35 106.49,31.97 115.15,31.97 115.55,32.36 118.29,32.36 118.82,31.84 119.7,31.84 120.56,32.7 121.83,32.7 122.69,31.84 123.91,31.84 125.07,33 127.8,33 128.43,32.36 129.18,31.61 131.29,31.61 134.36,34.68 145.75,34.68 146.73,33.69 163.52,33.69 164.26,34.43 171.94,34.43 173.35,35.84 196.03,35.84 197.52,37.33 205.27,37.33 207.37,39.44 208.48,39.44 209.5,40.46 210.35,40.46 v1(211.13,39.67)
  BOTTOM w0.112: RC14.1 108.5,49.97 107.22,48.69 107.22,45.15 106.51,44.44 106.51,43.5 104.81,41.8 104.81,33.02 105.63,32.2 105.63,31.52 104.8,30.7 102.11,30.7 100.32,32.48 99.01,32.48 98.04,33.46 96.05,33.46 95.03,32.44 v1(95.03,28.57)
TOUCH_SCREEN_RST: length 128.7
  TOP w0.112: v1(134.9,46.68) 134.94,46.64 v2(134.94,46.1) ; v1(213.68,48.79) 213.99,48.79 R88.2
  IN1 w0.119: v1(213.68,48.79) 213.87,48.99 215.05,48.99 215.3,49.24 215.3,50.1 215.93,50.73 216.32,50.73 216.7,51.12 217.11,51.12 218.48,49.75 219.53,49.75 219.9,49.37 219.9,38.7 220.29,38.32 220.29,35.98 v1(220.14,35.83)
  IN3 w0.135: v1(220.14,35.83) 220.14,33.61 218.4,31.87 215.87,31.87 215.17,31.17 181.48,31.17 178.3,27.98 174.62,27.98 174.18,27.54 172.2,27.54 170.08,29.66 165.47,29.66 164.62,30.51 163.71,30.51 163.48,30.28 158.28,30.28 157.26,29.27 151,29.27 144.51,35.76 143.57,35.76 141.24,38.09 141.24,40.63 138.23,43.65 138.23,45.43 137.31,46.35 136.24,46.35 135.9,46.68 v1(134.9,46.68)
  BOTTOM w0.076: UC1.CP4 134.62,48.22 134.51,48.11 134.51,47.58 134.9,47.18 v1(134.9,46.68)
  BOTTOM w0.112: v1(213.68,48.79) 213.2,48.79 212.85,48.45 JEDP1.25
TP_EN#: length 146.2
  TOP w0.112: UE1.49 49.89,75.81 49.42,76.27 45.56,76.27 45.19,75.9 40.45,75.9 v1(40.34,76)
  IN3 w0.135: v1(40.34,76) 40.34,75.52 38.54,73.71 38.54,69.31 36.04,66.82 31.48,66.82 30.88,67.41 29.97,67.41 25.42,62.86 23.87,62.86 23.68,62.67 22.39,62.67 21.62,61.91 21.62,59.49 24.8,56.32 27.53,56.32 35.58,48.27 35.58,45.39 39.86,41.11 39.86,37.64 42.53,34.97 46.74,34.97 48.47,33.24 48.47,32.22 48.68,32.01 55.73,32.01 57.4,30.33 58.09,30.33 61.44,26.98 67.74,26.98 68.46,26.27 94.82,26.27 96.81,28.25 v1(96.81,28.38)
  BOTTOM w0.112: v1(96.81,28.38) 98.79,26.4 v2(99.31,26.4) R41.1
TP_LOCK#: length 8.8
  BOTTOM w0.112: D5.2 118.6,33.2 118.86,32.94 R46.2 118.86,32.05 118.97,31.94 119.98,31.94 v2(120.19,32.14) 120.94,32.89 122.78,32.89 123.05,32.62 JTP1.3
TP_WAKE_KBC#: length 148.8
  TOP w0.112: Q8.1 127.06,31.43 126.55,31.94 v1(126.55,32.32) ; UE1.33 52.11,69.41 53.04,68.47 RE12.1 52.59,67.75 v1(52.4,67.94)
  IN2 w0.124: v1(126.55,32.32) 125.07,32.32 124.14,31.39 122.21,31.39 121.41,32.19 120.94,32.19 120.14,31.39 118.63,31.39 118.11,31.91 115.73,31.91 115.34,31.52 105.37,31.52 105.24,31.64 v1(105.24,31.68) ; v1(108.11,51.47) 108.11,51.05 107.03,49.97 106.54,49.97 105.58,49.02 103.99,49.02 103.52,48.55 101.55,48.55 99.67,46.67 88.71,46.67 85.87,43.83 81.45,43.83 80.78,43.16 79.6,43.16 77.78,41.33 70.81,41.33 69.79,42.36 63.63,42.36 62.91,43.08 61.65,43.08 61.09,43.63 57.99,43.63 57.35,44.28 57.35,46.69 54.64,49.39 54.64,63.93 53.79,64.78 53.79,66.55 v1(52.4,67.94)
  BOTTOM w0.112: DZ1.1 108.28,51.64 v1(108.11,51.47) 108.11,51 106.83,49.72 103.72,49.72 101.76,47.75 101.76,42.5 v2(99.36,40.11) 95.76,36.51 95.76,35.98 94.52,34.74 94.52,33.83 94.63,33.71 98.08,33.71 99.1,32.7 100.42,32.7 102.2,30.91 104.44,30.91 105.21,31.68 v1(105.24,31.68)
