# Allegro board LAG711PR10-1109.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YUQIU_PJ753-F07J1BE-B_7P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(9.5,-5.5) 3(9.5,-8.6) 4(0,-7.8) 5(9.5,0) 6(9.5,-2.75) 7(0,-2.65)

## Nets
0.6V_DDR_VTT_ON: CC2.1 PRM09.1 RC19.2 UC2.4
1.0V_VCCST_EN: CZ3.1 DZ5.2 RZ1.2 UZ1.3
1.2V_VTT_PWRGD: CC77.2 PRM06.2 PUM01.10 RC147.1
+0.6V_DDR_VTT: CD3.1 CD4.1 CD5.1 CD30.1 CD31.1 CD32.1 JDIMM1.258 JDIMM2.258 PJPM03.2
+0.6VSP: PCM20.1 PJPM03.1 PUM01.2 PUM01.20
+0.95VSDGPU: JP10.2 LV8.1 RV1.2 RV3.2 RV23.1 RV30.1 RV31.1
+0.95VSDGPU_ON: CZ32.2 RZ6.2 UZ6.3
+0.95VSDGPU_OUT: CZ34.1 JP10.1 UZ6.13 UZ6.14
+1.2V_DDR: CC1.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CC47.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CZ38.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJPM02.2 RD1.1 RD8.1 RD10.1 RD14.1 RD21.1 RZ11.1 UC1.AD36 UC1.AH32 UC1.AH36 UC1.AM36 UC1.AN32 UC1.AW32 UC1.AY36 UC1.BE32 UC1.BH36 UC1.R32 UC1.Y36 UC2.5 UZ7.1 UZ7.2 UZ7.7
+1.2VP: PCM05.1 PCM06.1 PCM07.1 PCM08.1 PCM09.1 PCM10.1 PCM17.2 PCM18.1 PJPM02.1 PLM01.1 PRM10.2 PUM01.5 PUM01.19
+1.05V_MPHY: CC49.1 RC128.2 UC1.BV12 UC1.BV14 UC1.BW12 UC1.BW14 UC1.BY12 UC1.BY14
+1.05V_MPHYPLL: CC53.1 CC54.1 RC129.2 UC1.BV2
+1.05V_PRIM: CC48.1 CC55.1 CC62.1 CE15.1 CZ2.1 CZ9.1 CZ29.1 PJPH02.2 RC128.1 RC129.1 RC130.1 RC153.1 UC1.BP14 UC1.BP20 UC1.BP22 UC1.BR12 UC1.BR14 UC1.BR15 UC1.BR20 UC1.BT12 UC1.BT18 UC1.BT19 UC1.BT22 UC1.BU12 UC1.BU14 UC1.BU15 UC1.BU18 UC1.BU19 UC1.BU22 UC1.BV15 UC1.BV16 UC1.BV18 UC1.BV19 UC1.BV20 UC1.BV22 UC1.BW16 UC1.BW18 UC1.BW19 UC1.BW20 UC1.BW22 UC1.BY16 UC1.BY20 UC1.CA12 UC1.CA14 UC1.CA16 UC1.CA18 UC1.CA19 UC1.CA20 UC1.CB12 UC1.CB14 UC1.CB15 UC1.CC12 UE1.95 UZ1.1 UZ1.2 UZ1.6 UZ1.7 UZ2.1 UZ2.2 UZ2.7 UZ6.1 UZ6.2
+1.05V_VCCDSW: CC59.1 UC1.BT24
+1.05V_XTAL: CC56.1 CC57.1 RC130.2 UC1.CP5
+1.05VALWP: PCH05.1 PCH06.1 PCH07.1 PCH08.1 PCH14.1 PJPH02.1 PLH01.2 PRH08.2
+1.8V_AVDD: CA3.2 RA2.2 UA1.33
+1.8V_CPVDD: CA10.2 CA11.1 RA5.2 UA1.29
+1.8V_PRIM: CC61.1 CC64.1 CT6.1 CT11.1 CZ31.1 PJP1802.2 QA1.1 R26.1 RC52.1 RC53.1 RC121.1 RC122.1 RC162.1 RC200.1 RC202.1 RE7.1 RT12.1 RT13.1 RT14.1 RT15.1 RT16.1 UC1.CC15 UC1.CC18 UC1.CC19 UC1.CD15 UC1.CD16 UC1.CD18 UC1.CD19 UC1.CP17 UC1.CP23 UT2.5 UZ6.6 UZ6.7
+1.8VALW_EC: CE13.1 RE7.2 UE1.54
+1.8VALWP: PC1802.1 PC1803.1 PC1804.1 PC1807.1 PJP1802.1 PL1801.2 PR1807.1
+1.8VGS: CV49.1 CV50.1 JP11.2 LV2.1 LV6.1 LV7.1 PRV12.1 RV7.1 RV8.1 RV11.1 RV13.1 RV15.1 RV25.1 RV27.1 RV81.2 RV82.2 UV1.AM30
+1.8VGS_GPU_ON: CZ33.2 RZ7.2 UZ6.5
+1.8VGS_OUT: CZ37.1 JP11.1 UZ6.8 UZ6.9
+1.35V_MEM_GFX: CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV46.1 CV47.1 CV152.1 CV153.1 CV154.1 CV155.1 CV156.1 CV157.1 CV158.1 CV159.1 CV160.1 CV161.1 CV162.1 CV163.1 CV164.1 CV165.1 CV166.1 CV167.1 CV168.1 CV169.1 CV170.1 CV173.1 CV174.1 CV175.1 CV176.1 CV177.1 CV178.1 CV179.1 CV180.1 CV181.1 CV182.1 CV183.1 CV184.1 CV185.1 CV186.1 CV187.1 CV188.1 CV189.1 CV190.1 CV191.1 PJPW02.2 RV32.1 RV33.1 RV48.1 RV50.1 RV52.1 RV54.1 RV78.1 RV79.1 RV85.1 RV86.1 UV1.H13 UV1.H16 UV1.H19 UV1.J9 UV1.J10 UV1.J23 UV1.J24 UV1.K9 UV1.K10 UV1.K23 UV1.K24 UV1.L11 UV1.L12 UV1.L13 UV1.L20 UV1.L21 UV1.L22 UV13.B1 UV13.B3 UV13.B12 UV13.B14 UV13.C5 UV13.C10 UV13.D1 UV13.D3 UV13.D11 UV13.D12 UV13.D14 UV13.E5 UV13.E10 UV13.F1 UV13.F3 UV13.F12 UV13.F14 UV13.G1 UV13.G2 UV13.G4 UV13.G11 UV13.G13 UV13.G14 UV13.H3 UV13.H12 UV13.K3 UV13.K12 UV13.L1 UV13.L2 UV13.L4 UV13.L11 UV13.L13 UV13.L14 UV13.M1 UV13.M3 UV13.M12 UV13.M14 UV13.N5 UV13.N10 UV13.P1 UV13.P3 UV13.P11 UV13.P12 UV13.P14 UV13.R5 UV13.R10 UV13.T1 UV13.T3 UV13.T12 UV13.T14 UV15.B1 UV15.B3 UV15.B12 UV15.B14 UV15.C5 UV15.C10 UV15.D1 UV15.D3 UV15.D11 UV15.D12 UV15.D14 UV15.E5 UV15.E10 UV15.F1 UV15.F3 UV15.F12 UV15.F14 UV15.G1 UV15.G2 UV15.G4 UV15.G11 UV15.G13 UV15.G14 UV15.H3 UV15.H12 UV15.K3 UV15.K12 UV15.L1 UV15.L2 UV15.L4 UV15.L11 UV15.L13 UV15.L14 UV15.M1 UV15.M3 UV15.M12 UV15.M14 UV15.N5 UV15.N10 UV15.P1 UV15.P3 UV15.P11 UV15.P12 UV15.P14 UV15.R5 UV15.R10 UV15.T1 UV15.T3 UV15.T12 UV15.T14
+1.35VGPUP: PCW05.1 PCW06.1 PCW07.1 PCW08.1 PCW14.1 PCW17.1 PCW18.1 PCW19.1 PCW20.1 PJPW02.1 PLW01.2 PRW09.2
+2.5V_MEM: CD1.1 CD2.1 CD28.1 CD29.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP2502.2
+2.5V_PG: DZ7.2 PR2505.2 PRM08.1 PU2501.1 RZ9.2
+2.5VP: PC2502.1 PC2505.1 PJP2502.1 PR2502.1 PU2501.6
+3.3V_SPI: CC4.1 CC74.1 RC30.2 RC31.1 RC35.1 RC36.1 RC37.1 RC149.1 RC207.1 UC1.BV23 UC3.8 UC11.8
+3.3V_WLAN: CW1.1 CW2.1 CW3.1 CW4.1 JWLAN1.2 JWLAN1.4 JWLAN1.72 JWLAN1.74 RW1.2 RW2.2
+3V_DVDD: CA12.2 CA13.1 CA14.1 CA15.1 RA6.2 RA12.1 RA15.2 UA1.1 UA1.8
+3V_HDA: CC60.1 RC51.1 RC131.2 UC1.BT20
+3VALW: C23.1 CC13.1 CC67.1 CC70.1 CL19.1 CX1.1 CX2.1 CZ14.1 CZ19.1 JDB1.11 JP5.2 JPWR1.4 PJP302.2 PJP1801.1 PJP2501.1 PL1811.1 PR5.2 PR33.1 PR41.2 PR1803.1 PR2505.1 PRB42.1 PRH03.1 PRH05.1 PRM06.1 PRW03.1 Q5.3 R89.1 RA9.2 RC174.1 RC175.1 RE5.1 RE18.2 RE19.2 RE21.2 RE23.2 RE28.1 RE58.1 RE66.1 RE67.1 RE68.1 RE69.1 RE70.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE76.1 RE77.1 RE78.1 RE79.1 RE80.1 RE81.1 RE82.1 RE83.1 RE84.1 RE85.1 RE86.1 RE87.1 RE88.1 RE89.1 RL10.1 RT6.2 RT7.2 RT8.2 RT10.2 RT11.2 RT23.1 RX18.2 UC5.5 UC6.5 UC8.5 UC9.5 UL2.5 UZ3.6 UZ3.7 UZ4.1 UZ4.2
+3VALW_1.8V: PC1801.1 PJP1801.2 PL1811.2 PU1801.8 PU1801.9 PU1801.10
+3VALW_2.5V: PC2501.1 PJP2501.2 PU2501.3
+3VALW_DSW: CC63.1 RC58.1 RC92.1 RC93.1 RC96.1 RC97.1 RC98.1 RC103.1 RC132.2 UC1.BR24 UC1.BT23
+3VALW_EC: CE1.1 CE2.1 CE3.2 CE4.2 CE5.1 CE6.1 CE7.1 CE8.1 CE9.1 CE17.1 CE21.1 JESPI1.1 JESPI1.2 R52.1 RE1.1 RE3.1 RE5.2 RE8.2 RE9.2 RE10.2 RE11.2 RE12.2 RE35.1 RE36.1 RE48.1 RE49.1 RE50.1 RE51.1 RE52.1 RE60.2 RE90.1 RE91.1 RE92.1 RE93.1 RE94.2 UE1.5 UE1.19 UE1.22 UE1.43 UE1.65 UE1.82 UE1.103 UE1.115
+3VALW_PCH: CC65.1 CC66.1 CZ23.1 JP8.2 RC30.1 RC33.1 RC34.1 RC38.1 RC44.1 RC46.1 RC57.1 RC59.1 RC62.1 RC65.1 RC69.1 RC70.1 RC100.1 RC110.1 RC111.1 RC112.1 RC113.1 RC115.1 RC117.1 RC118.1 RC131.1 RC132.1 RC182.1 RC183.1 RC188.2 RC189.2 RC190.2 RC191.2 RC196.1 RC197.1 RC198.1 RC199.1 RC208.1 RW1.1 RX16.2 RX17.2 UC1.BP23 UC1.BW23 UC1.CB16 UC1.CB22 UC1.CB23 UC1.CC22 UC1.CC23 UC1.CD22 UC1.CD23 UC1.CP29
+3VALW_PCH_OUT: JP8.1 UZ4.7 UZ4.8
+3VALWP: PC310.1 PC311.1 PC312.1 PC313.1 PC314.1 PC316.1 PJP302.1 PL301.2 PR304.1 PR306.2 PR307.1 PR504.1 PU301.14
+3VGS: CV32.2 JP9.2 PRV14.1 QV1.2 QV1.5 RP34.1 RP34.2 RP34.3 RP34.4 RV5.1 RV6.1 RV10.1 RV17.1 RV22.1 RV26.2 RV80.2 RV162.1 UV2.5 UV3.5
+3VGS_GPU_ON: CZ25.2 RZ5.2 UZ5.3
+3VGS_OUT: CZ27.1 JP9.1 UZ5.7 UZ5.8
+3VLP: D1.2 PC308.1 PU301.16 PU301.17 RE30.2
+3VS: C16.1 C28.1 CD6.1 CD7.1 CD33.1 CD34.1 CE22.1 CS32.1 CS33.1 CX3.1 CX4.1 CZ18.1 CZ24.1 JDIMM1.255 JDIMM2.255 JIOB1.12 JVGA1.14 JVGA1.15 PRV17.1 PRW05.1 PRZ16.1 Q9.2 Q10.2 Q10.5 Q11.2 Q11.5 QA1.2 QC1.2 QC1.5 QI2.2 QI3.2 QI3.5 R5.1 R6.1 R15.1 R30.1 R31.1 R36.1 R37.1 R47.1 R49.1 R50.1 R54.1 R55.1 R82.1 R86.1 R87.1 R88.1 R90.1 R91.1 R92.1 R95.1 RA6.1 RC5.1 RC6.1 RC7.1 RC8.1 RC9.1 RC19.1 RC27.1 RC28.1 RC29.1 RC68.1 RC78.1 RC81.1 RC85.1 RC88.1 RC106.1 RC109.1 RC114.1 RC127.2 RC146.1 RC203.1 RC204.1 RC206.1 RD2.1 RD4.1 RD6.1 RD15.1 RD17.1 RD19.1 RE16.2 RE17.2 RI13.1 RL8.1 RO1.2 RS3.1 RS30.1 RW2.1 RX1.1 RX12.2 RX15.2 RX19.2 RX20.2 U1.5 U3.1 UC4.5 UE2.5 US2.2 US2.3 US2.9 US2.10 UZ3.8 UZ3.9 UZ5.1 UZ5.2
+3VS_CAM: C36.1 JEDP1.29 R83.1 R95.2
+3VS_SSD: CS1.1 CS3.1 CS4.1 CS5.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 RS1.1 RS3.2
+5V_AVDD: CA1.1 CA2.1 RA3.2 UA1.20
+5V_HDD: CS29.1 CS30.1 CS31.1 JHDD1.10 JHDD1.11 JHDD1.12 RB9.2 RS31.1 RS32.2
+5V_HDMI: CI9.1 FI1.1 JHDMI1.18
+5V_KB_BL: C22.1 F3.1 JKBBL1.1
+5V_PVDD: CA4.1 CA5.1 CA6.1 CA7.1 RA1.2 UA1.34 UA1.39
+5VALW: CU13.1 CU16.1 CZ1.1 CZ10.1 CZ13.1 CZ21.1 CZ26.1 CZ30.1 CZ39.1 PCA08.1 PCG11.1 PCI11.1 PCI31.1 PCV12.1 PD2.3 PD3.3 PJP502.2 PJP503.2 PR4.1 PR2504.1 PRG02.1 PRH11.1 PRI02.1 PRI22.1 PRM04.1 PRM05.2 PRV13.1 PRW11.1 PRZ39.1 PRZ57.1 PUA01.4 PUG01.15 PUI01.2 PUI01.15 PUI02.2 PUI02.15 PUV01.26 PUV01.31 Q2.3 Q4.3 RT1.1 UU1.5 UU2.5 UZ1.4 UZ2.3 UZ3.1 UZ3.2 UZ3.4 UZ4.4 UZ5.4 UZ6.4 UZ7.3
+5VALW_25810: CT1.1 CT13.1 CT14.1 CT20.1 RT1.2 RT2.1 RT3.1 UT1.2 UT1.3 UT1.4 UT1.5
+5VALW_VDD: PC2504.1 PR2504.2 PU2501.4
+5VALWP: PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC519.1 PC520.1 PC521.1 PJP502.1 PJP503.1 PL501.2 PR509.2 PR510.1 PU501.14
+5VS: C27.1 CO1.1 CO2.1 CO3.1 CZ15.1 DI1.1 F3.2 FI1.2 JFAN1.1 JODD1.17 JODD1.18 JODD1.19 JODD1.20 JODD1.21 JODD1.22 JVGA1.16 Q12.3 QI1.2 R81.1 RA1.1 RA3.1 RB8.2 RS32.1 UZ3.13 UZ3.14
+17.4V_BATT+: PC11.1 PCB30.1 PCB31.1 PCB32.1 PCB33.1 PCB34.1 PCB35.1 PJP3.1 PL4.1 PQB28.3 PRB01.4 PRB35.1 PRB41.1 RB6.1
+17.4V_BATT++: PBATT1.8 PBATT1.9 PBATT1.10 PC12.1 PJP3.2 PL4.2
+17.4V_BATT+_R: PCB28.2 PD14.2 PLB01.2 PQB13.1 PQB13.2 PQB13.3 PRB01.1 RB5.1
+19V_ADPIN: PC1.1 PC2.1 PC15.1 PJP1.1 PJPDC1.5 PJPDC1.6 PL1.1
+19V_VIN: PC3.1 PC4.1 PC5.1 PC6.1 PDB01.2 PJP1.2 PL1.2 PQB11.5 PR32.1 PR34.1 PR36.1 PRB09.1
+19VB: F1.1 PD14.3 PDB13.2 PJP301.1 PJP501.1 PJPA01.1 PJPB01.1 PJPG01.1 PJPH01.1 PJPI01.1 PJPM01.1 PJPV01.1 PJPW01.1 PL311.1 PL511.1 PLB02.1 PLG11.1 PLH11.1 PLI11.1 PLM11.1 PLV11.1 PLW11.1 PQB13.5 PR302.2 PRA03.3 PRA03.4 PRB02.4 PRG04.3 PRG04.4 PRI24.3 PRI24.4 PRM12.1 PRM12.2 RB12.2
+19VB_1.2V: PCM01.1 PCM02.1 PCM03.1 PCM04.1 PCM22.1 PCM23.1 PJPM01.2 PLM11.2 PQM01.2 PQM01.3 PQM01.4 PQM01.10 PRM07.1 PRM12.3 PRM12.4 RB10.2
+19VB_1.05V: PCH01.1 PCH02.1 PCH03.1 PCH04.1 PCH15.1 PCH16.1 PJPH01.2 PLH11.2 PUH01.5
+19VB_3V: PC301.1 PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PJP301.2 PL311.2 PU301.2 PU301.3 PU301.4 PU301.5
+19VB_5V: PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PJP501.2 PL511.2 PU501.2 PU501.3 PU501.4 PU501.5
+19VB_+1.35VGPU: PCW01.1 PCW02.1 PCW03.1 PCW04.1 PCW15.1 PCW16.1 PJPW01.2 PLW11.2 PUW01.5
+19VB_CPU: PCI01.1 PCI02.1 PCI03.1 PCI04.1 PCI05.1 PCI06.1 PCI07.1 PCI08.1 PCI13.1 PCI14.1 PCI21.1 PCI22.1 PCI23.1 PCI24.1 PCI25.1 PCI26.1 PCI27.1 PCI28.1 PJPI01.2 PLI11.2 PRI24.1 PRI24.2 PRZ35.1 PUI01.8 PUI01.9 PUI02.8 PUI02.9 RB4.1
+19VB_DB: JDB1.1 JDB1.2 JDB1.15 JDB1.16 JDB1.20 RB12.1
+19VB_VGA: PCV01.1 PCV02.1 PCV03.1 PCV04.1 PCV05.1 PCV06.1 PCV07.1 PCV13.1 PCV14.1 PCV15.1 PCV16.1 PCV17.1 PCV18.1 PCV19.1 PCV35.1 PCV36.1 PJPV01.2 PLV11.2 PQV01.2 PQV02.2 PQV03.2 PQV04.2
+VCC_CORE: PCI101.1 PCI102.1 PCI103.1 PCI104.1 PCI105.1 PCI106.1 PCI107.1 PCI108.1 PCI109.1 PCI110.1 PCI113.1 PCI114.1 PCI115.1 PCI116.1 PCI117.1 PCI118.1 PCI119.1 PCI120.1 PCI121.1 PCI122.1 PCI123.1 PCI124.1 PCI125.1 PCI126.1 PCI127.1 PCI128.1 PCI129.1 PCI130.1 PCI151.1 PCI152.1 PCI153.1 PCI154.1 PCI155.1 PCI156.1 PCI157.1 PCI158.1 PCI159.1 PCI160.1 PCI161.1 PCI162.1 PCI163.1 PCI164.1 PCI165.1 PCI166.1 PCI167.1 PCI168.1 PCI169.1 PCI170.1 PCI171.1 PCI172.1 PCI173.1 PCI174.1 PCI175.1 PCI176.1 PCI177.1 PCI178.1 PCI179.1 PCI180.1 PCI181.1 PCI182.1 PCI183.1 PCI184.1 PCI185.1 PCI186.1 PCI187.1 PCI188.1 PCI189.1 PLI01.4 PLI02.4 PRC01.1 PRC02.1 PRC03.1 PRC04.1 PRC05.1 PRC06.1 RC167.1 UC1.AN9 UC1.AN10 UC1.AN24 UC1.AN26 UC1.AN27 UC1.AP2 UC1.AP9 UC1.AP24 UC1.AP26 UC1.AR5 UC1.AR6 UC1.AR7 UC1.AR8 UC1.AR10 UC1.AR25 UC1.AR27 UC1.AT9 UC1.AT24 UC1.AT26 UC1.AU5 UC1.AU6 UC1.AU7 UC1.AU8 UC1.AU9 UC1.AU24 UC1.AU25 UC1.AU26 UC1.AU27 UC1.AV2 UC1.AV5 UC1.AV7 UC1.AV10 UC1.AV27 UC1.AW5 UC1.AW6 UC1.AW7 UC1.AW8 UC1.AW9 UC1.AW10 UC1.AW24 UC1.AW25 UC1.AW26 UC1.AW27 UC1.AY24 UC1.AY26 UC1.BA5 UC1.BA7 UC1.BA8 UC1.BA25 UC1.BA27 UC1.BB2 UC1.BB26 UC1.BC5 UC1.BC6 UC1.BC7 UC1.BC9 UC1.BC10 UC1.BC26 UC1.BC27 UC1.BD5 UC1.BD8 UC1.BD10 UC1.BD25 UC1.BD27 UC1.BE9 UC1.BE24 UC1.BE25 UC1.BE26 UC1.BE27 UC1.BF2 UC1.BF9 UC1.BF24 UC1.BF26 UC1.BG27
+VCC_CORE_GT: PCC01.1 PCC02.1 PCC03.1 PCC04.1 PCI134.1 PCI135.1 PCI136.1 PCI137.1 PCI138.1 PCI139.1 PCI140.1 PRC01.2 PRC02.2 PRC03.2 PRC04.2 PRC05.2 PRC06.2 PRC07.2 PRC08.2 PRC09.2 PRC10.2 UC1.AA9 UC1.AB2 UC1.AB8 UC1.AB9 UC1.AB10 UC1.AC8 UC1.AD9 UC1.AE8 UC1.AE9 UC1.AE10 UC1.AF2 UC1.AF8 UC1.AF10 UC1.AG8 UC1.AG9 UC1.AH9 UC1.AJ8 UC1.AJ10 UC1.AK2 UC1.AK9 UC1.AL8 UC1.AL9 UC1.AL10 UC1.AM8 UC1.V2 UC1.Y8 UC1.Y10
+VCC_GT: PCG101.1 PCG102.1 PCG103.1 PCG104.1 PCG105.1 PCG106.1 PCG107.1 PCG108.1 PCG109.1 PCG110.1 PCG111.1 PCG112.1 PCG113.1 PCG114.1 PCG115.1 PCG116.1 PCG117.1 PCG118.1 PCG119.1 PCG120.1 PCG121.1 PCG122.1 PCG123.1 PCG124.1 PCG125.1 PCG126.1 PCG127.1 PCG128.1 PCG129.1 PCG130.1 PCG131.1 PCG132.1 PCG133.1 PCG134.1 PCG135.1 PCG171.1 PCG172.1 PLG01.4 PRC07.1 PRC08.1 PRC09.1 PRC10.1 RC169.1 UC1.A5 UC1.A6 UC1.A8 UC1.A11 UC1.A12 UC1.A14 UC1.A15 UC1.A17 UC1.A18 UC1.A20 UC1.B3 UC1.B4 UC1.B6 UC1.B8 UC1.B11 UC1.B14 UC1.B17 UC1.B20 UC1.C2 UC1.C3 UC1.C6 UC1.C7 UC1.C8 UC1.C11 UC1.C12 UC1.C14 UC1.C15 UC1.C17 UC1.C18 UC1.C20 UC1.D4 UC1.D7 UC1.D11 UC1.D12 UC1.D14 UC1.D15 UC1.D17 UC1.D18 UC1.D20 UC1.E4 UC1.F5 UC1.F6 UC1.F7 UC1.F8 UC1.F11 UC1.F14 UC1.F17 UC1.F20 UC1.G11 UC1.G12 UC1.G14 UC1.G15 UC1.G17 UC1.G18 UC1.G20 UC1.H5 UC1.H6 UC1.H7 UC1.H8 UC1.H11 UC1.H12 UC1.H14 UC1.H15 UC1.H17 UC1.H18 UC1.H20 UC1.J7 UC1.J8 UC1.J11 UC1.J14 UC1.J17 UC1.J20 UC1.K2 UC1.K11 UC1.L7 UC1.L8 UC1.L10 UC1.M9 UC1.N7 UC1.N8 UC1.N9 UC1.N10 UC1.P2 UC1.P8 UC1.R9 UC1.T8 UC1.T9 UC1.T10 UC1.U8 UC1.U10 UC1.V9 UC1.W8 UC1.W9
+VCC_SA: PCA101.1 PCA102.1 PCA103.1 PCA104.1 PCA105.1 PCA106.1 PCA107.1 PCA108.1 PCA109.1 PCA110.1 PCA111.1 PCA112.1 PCA113.1 PCA114.1 PCA115.1 PCA117.1 PCA118.1 PLA01.4 RC164.1 UC1.BG8 UC1.BG10 UC1.BH9 UC1.BJ8 UC1.BJ9 UC1.BJ10 UC1.BK8 UC1.BK25 UC1.BK27 UC1.BL8 UC1.BL9 UC1.BL10 UC1.BL24 UC1.BL26 UC1.BM24 UC1.BN25
+VCCIO: CC20.1 CC21.1 CC22.1 CC23.1 CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 JP3.2 RC4.1 UC1.AK24 UC1.AK26 UC1.AL24 UC1.AL25 UC1.AL26 UC1.AL27 UC1.AM25 UC1.AM27 UC1.BH24 UC1.BH25 UC1.BH26 UC1.BH27 UC1.BJ24 UC1.BJ26 UC1.BP16 UC1.BP18
+VCCIO_OUT: CZ12.1 JP3.1 UZ2.6
+VCCLDOSRAM_1P24: RC133.1 UC1.BY23 UC1.BY24 UC1.CA23 UC1.CA24
+VCCPLL_OC: CC17.1 CZ40.1 RZ11.2 RZ12.2 UC1.BL27 UC1.BM26
+VCCST: CC15.1 CC16.1 CC18.1 CC72.1 JP1.2 PCZ24.1 PRZ40.1 PRZ41.1 PRZ42.1 PRZ43.1 RC2.1 RC3.1 RC134.1 RC136.1 RC145.1 UC1.BP2 UC1.BP11 UC1.BR11 UC1.BT11
+VCCST_OUT: CZ5.1 JP1.1 UZ1.13 UZ1.14
+VCCSTG: CC19.1 JP2.2 RC1.1 RC150.1 RC151.1 RC152.1 UC1.BG1 UC1.BG2 UC1.BG3
+VCCSTG_OUT: CZ8.1 JP2.1 UZ1.8 UZ1.9
+VDD_CT: CV64.1 RV7.2 UV1.AA20 UV1.AA21 UV1.AB20 UV1.AB21
+VDDR3: CV65.1 RV10.2 UV1.AA17 UV1.AA18 UV1.AB17 UV1.AB18
GND: C1.2 C2.2 C3.2 C4.1 C5.2 C6.2 C7.2 C8.2 C9.2 C16.2 C18.2 C21.2 C22.2 C24.2 C25.2 C26.2 C27.2 C28.2 C33.2 C35.2 C36.2 C37.2 C39.2 CA4.2 CA5.2 CA6.2 CA7.2 CA8.2 CA9.2 CA10.1 CA11.2 CA12.1 CA13.2 CA14.2 CA15.2 CA18.2 CA20.1 CA22.1 CA25.2 CA28.2 CA29.2 CA30.2 CA31.2 CC1.2 CC2.2 CC3.2 CC4.2 CC5.1 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC14.2 CC15.2 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC74.2 CC75.2 CC76.2 CC77.1 CC78.1 CC79.1 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CE1.2 CE2.2 CE3.1 CE4.1 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.1 CE22.2 CE23.2 CE24.2 CE25.2 CE27.2 CE28.2 CE30.2 CE32.1 CI9.2 CL1.2 CL2.2 CL3.2 CL4.2 CL5.2 CL6.2 CL7.2 CL10.2 CL11.2 CL12.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CLRP1.2 CLRP2.2 CO1.2 CO2.2 CO3.2 CS1.2 CS3.2 CS4.2 CS5.2 CS29.2 CS30.2 CS31.2 CS32.2 CS33.2 CT1.2 CT6.2 CT11.2 CT12.2 CT13.2 CT14.2 CT15.2 CT16.2 CT17.2 CT18.2 CT20.2 CU4.2 CU5.2 CU6.2 CU7.2 CU9.2 CU10.2 CU11.2 CU12.2 CU13.2 CU16.2 CU17.2 CV17.2 CV18.2 CV20.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.1 CV33.2 CV34.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV49.2 CV50.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV81.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV120.2 CV121.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV157.2 CV158.2 CV159.2 CV160.2 CV161.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV167.2 CV168.2 CV169.2 CV170.2 CV171.2 CV172.2 CV173.2 CV174.2 CV175.2 CV176.2 CV177.2 CV178.2 CV179.2 CV180.2 CV181.2 CV182.2 CV183.2 CV184.2 CV185.2 CV186.2 CV187.2 CV188.2 CV189.2 CV190.2 CV191.2 CW1.2 CW2.2 CW3.2 CW4.2 CX1.2 CX2.2 CX3.2 CX4.2 CX5.2 CX6.2 CX7.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ10.2 CZ11.2 CZ12.2 CZ13.2 CZ14.2 CZ15.2 CZ16.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ22.2 CZ23.2 CZ24.2 CZ25.1 CZ26.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ32.1 CZ33.1 CZ34.2 CZ35.1 CZ36.1 CZ37.2 CZ38.2 CZ39.2 CZ40.2 CZ41.2 DA1.1 DA2.1 DA5.1 DA6.1 DA7.1 DE1.2 EC1.2 EC2.2 ED1.1 ED2.1 ED3.1 ED4.1 EU1.3 EU2.1 EU3.3 EU4.1 EU5.1 EU6.1 EU7.1 EU8.3 EU9.3 EU10.1 EU11.1 H1.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) HCPU1.1(TP-1) HCPU2.1(TP-1) HCPU3.1(TP-1) HCPU4.1(TP-1) JDB1.12 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JEDP1.13 JEDP1.17 JEDP1.20 JEDP1.23 JEDP1.32 JEDP1.35 JEDP1.38 JEDP1.41 JEDP1.42 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.4 JFAN1.5 JFAN1.6 JFP1.1 JFP1.3 JFP1.4 JFP1.9 JFP1.10 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIOB1.2 JIOB1.5 JIOB1.8 JIOB1.10 JIOB1.17 JIOB1.18 JKB1.30 JKB1.31 JKB1.32 JKBBL1.5 JKBBL1.6 JLAN1.9 JLAN1.10 JLAN1.11 JLAN1.12 JODD1.1 JODD1.2 JODD1.7 JODD1.8 JODD1.13 JODD1.14 JODD1.25 JODD1.26 JPWR1.1 JPWR1.5 JPWR1.6 JSPK1.5 JSPK1.6 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JTP1.5 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JVGA1.1 JVGA1.4 JVGA1.10 JVGA1.17 JVGA1.18 JWLAN1.1 JWLAN1.7 JWLAN1.13 JWLAN1.18 JWLAN1.19 JWLAN1.33 JWLAN1.39 JWLAN1.45 JWLAN1.51 JWLAN1.57 JWLAN1.63 JWLAN1.69 JWLAN1.75 JWLAN1.76 JWLAN1.77 LED1.1 LED1.3 PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PBATT1.11 PBATT1.12 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC11.2 PC12.2 PC15.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC316.2 PC317.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC519.2 PC520.2 PC521.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC2501.2 PC2502.2 PC2503.2 PC2504.2 PC2506.2 PCA01.2 PCA02.2 PCA03.2 PCA04.2 PCA05.2 PCA06.2 PCA08.2 PCA09.2 PCA101.2 PCA102.2 PCA103.2 PCA104.2 PCA105.2 PCA106.2 PCA107.2 PCA108.2 PCA109.2 PCA110.2 PCA111.2 PCA112.2 PCA113.2 PCA114.2 PCA115.2 PCA117.2 PCA118.2 PCB02.2 PCB04.2 PCB05.2 PCB07.2 PCB08.1 PCB09.2 PCB10.2 PCB11.2 PCB12.2 PCB13.2 PCB14.2 PCB16.2 PCB17.2 PCB19.2 PCB20.2 PCB21.2 PCB22.2 PCB23.2 PCB24.2 PCB25.2 PCB26.2 PCB27.2 PCB29.2 PCB30.2 PCB31.2 PCB32.2 PCB33.2 PCB34.2 PCB35.2 PCB36.2 PCB70.2 PCB71.2 PCC01.2 PCC02.2 PCC03.2 PCC04.2 PCG01.2 PCG02.2 PCG03.2 PCG04.2 PCG05.2 PCG06.2 PCG07.2 PCG08.2 PCG10.2 PCG11.2 PCG12.2 PCG13.2 PCG101.2 PCG102.2 PCG103.2 PCG104.2 PCG105.2 PCG106.2 PCG107.2 PCG108.2 PCG109.2 PCG110.2 PCG111.2 PCG112.2 PCG113.2 PCG114.2 PCG115.2 PCG116.2 PCG117.2 PCG118.2 PCG119.2 PCG120.2 PCG121.2 PCG122.2 PCG123.2 PCG124.2 PCG125.2 PCG126.2 PCG127.2 PCG128.2 PCG129.2 PCG130.2 PCG131.2 PCG132.2 PCG133.2 PCG134.2 PCG135.2 PCG171.2 PCG172.2 PCH01.2 PCH02.2 PCH03.2 PCH04.2 PCH05.2 PCH06.2 PCH07.2 PCH08.2 PCH09.2 PCH10.2 PCH11.2 PCH13.2 PCH15.2 PCH16.2 PCI01.2 PCI02.2 PCI03.2 PCI04.2 PCI05.2 PCI06.2 PCI07.2 PCI08.2 PCI10.2 PCI11.2 PCI12.2 PCI13.2 PCI14.2 PCI21.2 PCI22.2 PCI23.2 PCI24.2 PCI25.2 PCI26.2 PCI27.2 PCI28.2 PCI30.2 PCI31.2 PCI32.2 PCI101.2 PCI102.2 PCI103.2 PCI104.2 PCI105.2 PCI106.2 PCI107.2 PCI108.2 PCI109.2 PCI110.2 PCI113.2 PCI114.2 PCI115.2 PCI116.2 PCI117.2 PCI118.2 PCI119.2 PCI120.2 PCI121.2 PCI122.2 PCI123.2 PCI124.2 PCI125.2 PCI126.2 PCI127.2 PCI128.2 PCI129.2 PCI130.2 PCI134.2 PCI135.2 PCI136.2 PCI137.2 PCI138.2 PCI139.2 PCI140.2 PCI151.2 PCI152.2 PCI153.2 PCI154.2 PCI155.2 PCI156.2 PCI157.2 PCI158.2 PCI159.2 PCI160.2 PCI161.2 PCI162.2 PCI163.2 PCI164.2 PCI165.2 PCI166.2 PCI167.2 PCI168.2 PCI169.2 PCI170.2 PCI171.2 PCI172.2 PCI173.2 PCI174.2 PCI175.2 PCI176.2 PCI177.2 PCI178.2 PCI179.2 PCI180.2 PCI181.2 PCI182.2 PCI183.2 PCI184.2 PCI185.2 PCI186.2 PCI187.2 PCI188.2 PCI189.2 PCM01.2 PCM02.2 PCM03.2 PCM04.2 PCM05.2 PCM06.2 PCM07.2 PCM08.2 PCM09.2 PCM10.2 PCM11.2 PCM13.2 PCM14.2 PCM15.2 PCM16.2 PCM18.2 PCM19.2 PCM20.2 PCM22.2 PCM23.2 PCV01.2 PCV02.2 PCV03.2 PCV04.2 PCV05.2 PCV06.2 PCV07.2 PCV09.2 PCV10.2 PCV11.2 PCV12.2 PCV13.2 PCV14.2 PCV15.2 PCV16.2 PCV17.2 PCV18.2 PCV19.2 PCV20.2 PCV24.2 PCV27.2 PCV31.2 PCV32.2 PCV34.2 PCV35.2 PCV36.2 PCV171.2 PCV172.2 PCW01.2 PCW02.2 PCW03.2 PCW04.2 PCW05.2 PCW06.2 PCW07.2 PCW08.2 PCW09.2 PCW10.2 PCW11.2 PCW13.2 PCW15.2 PCW16.2 PCW17.2 PCW18.2 PCW19.2 PCW20.2 PCZ02.2 PCZ03.2 PCZ05.2 PCZ12.2 PCZ14.2 PCZ19.2 PCZ22.2 PCZ23.2 PCZ24.2 PCZ25.2 PCZ30.2 PCZ32.2 PCZ33.2 PCZ34.2 PCZ36.2 PD1.1 PD2.2 PD3.2 PD5.1 PD6.1 PD14.1 PDB13.1 PDM01.2 PHV01.2 PHZ04.2 PHZ05.2 PJP2.2 PJPDC1.7 PJPDC1.8 PL2.2 PQ2.3 PQ11.3 PQ12.1 PQ12.4 PQ13.1 PQ13.4 PQA01.5 PQA01.6 PQA01.7 PQB25.1 PQB25.2 PQB25.3 PQB29.3 PQB31.3 PQB32.3 PQB33.3 PQM01.5 PQM01.6 PQM01.7 PQV01.3 PQV01.4 PQV01.5 PQV02.3 PQV02.4 PQV02.5 PQV03.3 PQV03.4 PQV03.5 PQV04.3 PQV04.4 PQV04.5 PR6.2 PR38.2 PR40.2 PR43.2 PR44.1 PR45.2 PR303.2 PR308.2 PR508.2 PR511.2 PR1802.2 PR1805.2 PR2503.2 PRB04.2 PRB10.2 PRB13.1 PRB16.2 PRB17.1 PRB23.2 PRB26.2 PRB28.1 PRB34.2 PRB38.2 PRB45.2 PRH02.2 PRH04.2 PRH09.2 PRM11.2 PRV02.2 PRV04.2 PRV05.2 PRV09.2 PRV10.2 PRV16.2 PRV18.2 PRV27.2 PRW02.2 PRW04.2 PRW10.2 PRZ01.2 PRZ05.2 PRZ11.1 PRZ15.2 PRZ23.2 PRZ36.2 PRZ50.2 PRZ55.2 PRZ56.2 PRZ60.2 PRZ64.2 PRZ65.2 PRZ66.2 PRZ67.2 PRZ68.2 PRZ69.2 PU301.7 PU301.8 PU301.18 PU301.21 PU501.7 PU501.8 PU501.18 PU501.21 PU1801.11 PU2501.8 PU2501.9 PUA01.6 PUA01.9 PUB01.33 PUG01.2 PUG01.4 PUG01.10 PUG01.14 PUG01.18 PUH01.4 PUH01.8 PUI01.4 PUI01.10 PUI01.14 PUI01.18 PUI02.4 PUI02.10 PUI02.14 PUI02.18 PUM01.1 PUM01.3 PUM01.14 PUM01.21 PUV01.41 PUW01.4 PUW01.8 PUZ01.49 Q1.3 Q6.3 Q7.3 Q16.1 Q16.4 Q18.3 QI1.3 QS1.1 QS1.4 QT1.1 QT1.4 R2.2 R17.2 R40.2 R53.2 R65.1 R72.2 R75.1 R76.1 R77.1 RA10.1 RA16.2 RA17.2 RA18.2 RA24.2 RC10.1 RC11.1 RC12.1 RC13.1 RC15.2 RC16.2 RC17.2 RC18.2 RC20.2 RC54.1 RC55.2 RC56.2 RC60.1 RC61.1 RC63.2 RC64.2 RC66.1 RC71.2 RC72.2 RC73.1 RC74.1 RC75.1 RC83.2 RC86.2 RC94.2 RC104.2 RC105.2 RC107.2 RC108.1 RC116.1 RC119.2 RC120.2 RC123.2 RC124.2 RC125.2 RC137.1 RC138.1 RC139.2 RC140.1 RC141.1 RC142.1 RC143.1 RC156.2 RC157.2 RC158.2 RC165.2 RC168.2 RC170.2 RC171.2 RC172.2 RC173.2 RC187.1 RC201.2 RC205.1 RC209.2 RD3.2 RD5.2 RD7.2 RD12.2 RD13.2 RD16.2 RD18.2 RD20.2 RD23.2 RD24.2 RE22.2 RE24.2 RE26.2 RE32.2 RE40.2 RE44.1 RE45.1 RE57.2 RI16.2 RL7.1 RL9.2 RL11.1 RT9.2 RT17.1 RT18.1 RT19.1 RT20.1 RV2.1 RV4.2 RV9.2 RV12.2 RV14.2 RV16.2 RV18.1 RV19.2 RV21.1 RV29.1 RV34.2 RV35.2 RV38.2 RV39.1 RV40.1 RV41.1 RV43.2 RV49.2 RV51.2 RV53.2 RV55.2 RV59.1 RV83.2 RV88.1 RV89.1 RV117.2 RV119.2 RV121.2 RV123.2 RV134.2 RV135.2 RV151.2 RV152.1 RV163.2 RV165.2 RX11.1 RX13.2 RX14.2 RX21.1 RX22.1 SW1.2 U1.2 U2.2 U3.5 UA1.41 UC1.A3 UC1.A4 UC1.A32 UC1.A36 UC1.AB3 UC1.AB4 UC1.AB7 UC1.AB27 UC1.AB30 UC1.AB33 UC1.AB36 UC1.AC5 UC1.AC10 UC1.AC27 UC1.AC30 UC1.AD33 UC1.AD35 UC1.AE7 UC1.AE24 UC1.AE25 UC1.AE26 UC1.AE27 UC1.AE30 UC1.AF3 UC1.AF4 UC1.AF7 UC1.AF25 UC1.AF27 UC1.AF30 UC1.AF33 UC1.AF36 UC1.AG5 UC1.AG10 UC1.AG24 UC1.AG26 UC1.AH24 UC1.AH25 UC1.AH27 UC1.AH28 UC1.AH29 UC1.AH30 UC1.AH31 UC1.AH33 UC1.AH35 UC1.AJ7 UC1.AJ25 UC1.AJ28 UC1.AK3 UC1.AK4 UC1.AK33 UC1.AK36 UC1.AL7 UC1.AL28 UC1.AL29 UC1.AL32 UC1.AM5 UC1.AM10 UC1.AM28 UC1.AM33 UC1.AM35 UC1.AN7 UC1.AN8 UC1.AN25 UC1.AN28 UC1.AN29 UC1.AN30 UC1.AN31 UC1.AP3 UC1.AP4 UC1.AP33 UC1.AP36 UC1.AR4 UC1.AR28 UC1.AT4 UC1.AT33 UC1.AT35 UC1.AT36 UC1.AU4 UC1.AU10 UC1.AU28 UC1.AU29 UC1.AU32 UC1.AV3 UC1.AV4 UC1.AV6 UC1.AV8 UC1.AV25 UC1.AV28 UC1.AV33 UC1.AV36 UC1.AW1 UC1.AW3 UC1.AW4 UC1.AW28 UC1.AW29 UC1.AW30 UC1.AW31 UC1.AY4 UC1.AY33 UC1.AY35 UC1.B2 UC1.B5 UC1.B7 UC1.B9 UC1.B12 UC1.B15 UC1.B18 UC1.B21 UC1.B23 UC1.B25 UC1.B27 UC1.B29 UC1.B31 UC1.B34 UC1.B36 UC1.B37 UC1.BA3 UC1.BA4 UC1.BA6 UC1.BA10 UC1.BA28 UC1.BB3 UC1.BB4 UC1.BB33 UC1.BB36 UC1.BC4 UC1.BC8 UC1.BC25 UC1.BC29 UC1.BC32 UC1.BD4 UC1.BD6 UC1.BD7 UC1.BD28 UC1.BD33 UC1.BD35 UC1.BD36 UC1.BE3 UC1.BE4 UC1.BE8 UC1.BE10 UC1.BE28 UC1.BE29 UC1.BE30 UC1.BE31 UC1.BF3 UC1.BF4 UC1.BF33 UC1.BF36 UC1.BG4 UC1.BG25 UC1.BG28 UC1.BH28 UC1.BH29 UC1.BH32 UC1.BH33 UC1.BH35 UC1.BJ7 UC1.BK2 UC1.BK3 UC1.BK4 UC1.BK7 UC1.BK10 UC1.BK28 UC1.BK33 UC1.BL7 UC1.BL25 UC1.BL28 UC1.BL29 UC1.BL30 UC1.BL31 UC1.BL32 UC1.BM9 UC1.BM33 UC1.BM35 UC1.BM36 UC1.BN7 UC1.BN30 UC1.BP3 UC1.BP4 UC1.BP7 UC1.BP12 UC1.BP15 UC1.BP19 UC1.BP25 UC1.BP32 UC1.BP33 UC1.BP36 UC1.BR16 UC1.BR19 UC1.BR22 UC1.BR25 UC1.BT5 UC1.BT14 UC1.BT15 UC1.BT16 UC1.BT25 UC1.BT28 UC1.BT33 UC1.BT35 UC1.BT36 UC1.BU7 UC1.BU11 UC1.BU16 UC1.BU20 UC1.BU23 UC1.BU24 UC1.BU25 UC1.BV3 UC1.BV4 UC1.BV11 UC1.BV31 UC1.BV33 UC1.BW7 UC1.BW11 UC1.BW15 UC1.BW24 UC1.BY5 UC1.BY11 UC1.BY15 UC1.BY18 UC1.BY19 UC1.BY22 UC1.BY25 UC1.BY28 UC1.BY33 UC1.BY35 UC1.BY36 UC1.C1 UC1.C4 UC1.C9 UC1.C21 UC1.C25 UC1.C29 UC1.C33 UC1.C36 UC1.C37 UC1.CA11 UC1.CA15 UC1.CA22 UC1.CA25 UC1.CB2 UC1.CB3 UC1.CB4 UC1.CB7 UC1.CB11 UC1.CB18 UC1.CB19 UC1.CB20 UC1.CB24 UC1.CB25 UC1.CB33 UC1.CC7 UC1.CC11 UC1.CC14 UC1.CC16 UC1.CC20 UC1.CC24 UC1.CC25 UC1.CC28 UC1.CC31 UC1.CD11 UC1.CD12 UC1.CD14 UC1.CD20 UC1.CD24 UC1.CD25 UC1.CE7 UC1.CE33 UC1.CE35 UC1.CE36 UC1.CF2 UC1.CF3 UC1.CF4 UC1.CF11 UC1.CF14 UC1.CF19 UC1.CF23 UC1.CF28 UC1.CG7 UC1.CG33 UC1.CH31 UC1.CJ2 UC1.CJ3 UC1.CJ4 UC1.CJ11 UC1.CJ14 UC1.CJ19 UC1.CJ23 UC1.CJ28 UC1.CJ33 UC1.CJ35 UC1.CJ36 UC1.CK1 UC1.CK4 UC1.CK7 UC1.CK37 UC1.CL2 UC1.CM1 UC1.CM4 UC1.CM5 UC1.CM9 UC1.CM13 UC1.CM17 UC1.CM21 UC1.CM25 UC1.CM29 UC1.CM31 UC1.CM33 UC1.CM37 UC1.CN1 UC1.CN2 UC1.CN5 UC1.CN9 UC1.CN13 UC1.CN17 UC1.CN21 UC1.CN25 UC1.CN29 UC1.CN37 UC1.CP1 UC1.CP2 UC1.CP9 UC1.CP11 UC1.CP13 UC1.CP15 UC1.CP19 UC1.CP21 UC1.CP27 UC1.CP35 UC1.CP37 UC1.CR2 UC1.CR6 UC1.CR34 UC1.CR36 UC1.D1 UC1.D5 UC1.D6 UC1.D8 UC1.D9 UC1.D21 UC1.D25 UC1.E9 UC1.E23 UC1.E27 UC1.E29 UC1.E31 UC1.E33 UC1.E35 UC1.F2 UC1.F3 UC1.F4 UC1.F12 UC1.F15 UC1.F18 UC1.F21 UC1.F24 UC1.F33 UC1.G9 UC1.G21 UC1.G27 UC1.G33 UC1.G35 UC1.G36 UC1.H9 UC1.H21 UC1.H27 UC1.J5 UC1.J6 UC1.J12 UC1.J15 UC1.J18 UC1.J21 UC1.J24 UC1.J33 UC1.J36 UC1.K3 UC1.K4 UC1.K9 UC1.K21 UC1.K22 UC1.K24 UC1.K25 UC1.K27 UC1.K28 UC1.K29 UC1.K30 UC1.K31 UC1.K32 UC1.L6 UC1.L27 UC1.L33 UC1.L35 UC1.L36 UC1.N6 UC1.N25 UC1.N27 UC1.P3 UC1.P4 UC1.P7 UC1.P10 UC1.P33 UC1.P36 UC1.R27 UC1.R28 UC1.R29 UC1.R30 UC1.R31 UC1.T7 UC1.T27 UC1.T30 UC1.T33 UC1.T35 UC1.T36 UC1.U7 UC1.U24 UC1.U26 UC1.V3 UC1.V4 UC1.V26 UC1.V27 UC1.V30 UC1.V33 UC1.V36 UC1.W7 UC1.W10 UC1.W27 UC1.W30 UC1.Y7 UC1.Y26 UC1.Y27 UC1.Y30 UC1.Y33 UC1.Y35 UC2.3 UC3.4 UC4.3 UC5.3 UC6.3 UC8.3 UC9.3 UC11.4 UE1.17 UE1.51 UE1.64 UE1.84 UE1.100 UE1.124 UE2.3 UL1.33 UL2.2 US2.5 US2.6 US2.7 US2.8 UT1.12 UT1.21 UT2.19 UU1.2 UU2.2 UV1.A3 UV1.A30 UV1.AA11 UV1.AA13 UV1.AA16 UV1.AA27 UV1.AB6 UV1.AB10 UV1.AB15 UV1.AB24 UV1.AB32 UV1.AC9 UV1.AC17 UV1.AC24 UV1.AC26 UV1.AC27 UV1.AD6 UV1.AD8 UV1.AD25 UV1.AD32 UV1.AE7 UV1.AE14 UV1.AE27 UV1.AF32 UV1.AG12 UV1.AG27 UV1.AH10 UV1.AH28 UV1.AH32 UV1.B6 UV1.B8 UV1.B10 UV1.B12 UV1.B14 UV1.B16 UV1.B18 UV1.B20 UV1.B22 UV1.B24 UV1.B26 UV1.C1 UV1.C32 UV1.E28 UV1.F2 UV1.F6 UV1.F8 UV1.F10 UV1.F12 UV1.F14 UV1.F16 UV1.F18 UV1.F20 UV1.F22 UV1.F24 UV1.F26 UV1.G8 UV1.G10 UV1.G27 UV1.G31 UV1.H2 UV1.H6 UV1.H14 UV1.H17 UV1.H20 UV1.J7 UV1.J27 UV1.J31 UV1.K2 UV1.K6 UV1.K11 UV1.K22 UV1.K28 UV1.K32 UV1.L27 UV1.M6 UV1.M12 UV1.M32 UV1.N11 UV1.N13 UV1.N16 UV1.N18 UV1.N21 UV1.N25 UV1.N27 UV1.P6 UV1.P9 UV1.P25 UV1.P32 UV1.R11 UV1.R12 UV1.R15 UV1.R17 UV1.R20 UV1.R27 UV1.T6 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T25 UV1.T32 UV1.U9 UV1.U15 UV1.U17 UV1.U20 UV1.U25 UV1.U27 UV1.V11 UV1.V13 UV1.V16 UV1.V18 UV1.V32 UV1.W25 UV1.W26 UV1.W27 UV1.Y10 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y25 UV1.Y32 UV2.3 UV3.3 UV13.A1 UV13.A3 UV13.A12 UV13.A14 UV13.B5 UV13.B10 UV13.C1 UV13.C3 UV13.C4 UV13.C11 UV13.C12 UV13.C14 UV13.D10 UV13.E1 UV13.E3 UV13.E12 UV13.E14 UV13.F5 UV13.F10 UV13.G5 UV13.G10 UV13.H1 UV13.H2 UV13.H13 UV13.H14 UV13.K1 UV13.K2 UV13.K13 UV13.K14 UV13.L5 UV13.L10 UV13.M5 UV13.M10 UV13.N1 UV13.N3 UV13.N12 UV13.N14 UV13.P10 UV13.R1 UV13.R3 UV13.R4 UV13.R11 UV13.R12 UV13.R14 UV13.T5 UV13.T10 UV13.U1 UV13.U3 UV13.U12 UV13.U14 UV15.A1 UV15.A3 UV15.A12 UV15.A14 UV15.B5 UV15.B10 UV15.C1 UV15.C3 UV15.C4 UV15.C11 UV15.C12 UV15.C14 UV15.D10 UV15.E1 UV15.E3 UV15.E12 UV15.E14 UV15.F5 UV15.F10 UV15.G5 UV15.G10 UV15.H1 UV15.H2 UV15.H13 UV15.H14 UV15.K1 UV15.K2 UV15.K13 UV15.K14 UV15.L5 UV15.L10 UV15.M5 UV15.M10 UV15.N1 UV15.N3 UV15.N12 UV15.N14 UV15.P10 UV15.R1 UV15.R3 UV15.R4 UV15.R11 UV15.R12 UV15.R14 UV15.T5 UV15.T10 UV15.U1 UV15.U3 UV15.U12 UV15.U14 UX1.33 UZ1.11 UZ1.15 UZ2.5 UZ3.11 UZ3.15 UZ4.5 UZ4.9 UZ5.5 UZ5.9 UZ6.11 UZ6.15 UZ7.5 YL1.2 YL1.4 YV1.2 YV1.4
V3D3_STB: RA9.1 RA11.1 UA1.16
VBAT_CHG: PCB14.1 PRB35.2 PUB01.31
VCC_CPU: PCZ34.1 PRZ57.2 PUZ01.13
VCC_GT_SENSE: PRZ59.1 RC169.2 UC1.E3
VCC_VCORE1: PCI10.1 PRI02.2 PUI01.3
VCC_VCORE2: PCI30.1 PRI22.2 PUI02.3
VCC_VGT1: PCG10.1 PRG02.2 PUG01.3
VCCDPHY_1P24: CC58.1 RC133.2 UC1.CP25
VCCDSW_EN: DZ2.2 RE58.2 RZ8.1 UE1.88
VCCGT_B+: PCG01.1 PCG02.1 PCG03.1 PCG04.1 PCG05.1 PCG06.1 PCG07.1 PCG08.1 PCG13.1 PJPG01.2 PLG11.2 PRG04.1 PRG04.2 PUG01.8 PUG01.9 RB7.2
VCCIO_SENSE: TP30.1(TP-1) UC1.BP28
VCCSA_B+: PCA01.1 PCA02.1 PCA03.1 PCA04.1 PCA05.1 PCA06.1 PJPA01.2 PQA01.2 PQA01.3 PQA01.4 PQA01.10 PRA03.1 PRA03.2 RB11.2
VCCSENSE: PRZ14.1 RC167.2 UC1.AN6
VCCSENSE_VGA: PRV34.1 RV42.1 RV159.2
VCCST_PWRGD: RC99.2 UC1.BJ2
VCCSTG_IO_EN: CZ4.1 DZ6.1 RZ2.2 RZ3.1 RZ10.1 UC9.4 UZ1.5
VCCSTG_IO_EN_R: CZ11.1 DZ6.2 RZ3.2 UZ2.4
VDD10: CL3.1 CL4.1 CL5.1 CL6.1 CL16.1 CL18.1 RL1.2 UL1.3 UL1.8 UL1.22 UL1.30
VDD_1.2V: PCM14.1 PRM03.2 PRM04.2 PUM01.11
VDD_CHG: PCB08.2 PRB18.2 PRB25.1 PRB27.1 PRB39.2 PRB44.1 PUB01.18
VDDIO_VGA: PCV10.1 PRV12.2 PRV14.2 PUV01.6
VDDP_1.2V: PCM13.1 PDM01.1 PRM05.1 PUM01.12
VDDP_CHG: PCB19.1 PRB39.1 PUB01.8
VDDR4: UV1.U12 UV1.V12 UV1.Y12
VDDREG: CL12.1 RL4.2 UL1.23
VSS_GT_SENSE: PRZ53.2 RC170.1 UC1.D2
VSS_MECH: UV1.A32 UV1.AM1 UV1.AM32
VSSIO_SENSE: TP31.1(TP-1) UC1.BP29
VSSSENSE: PRZ18.1 RC168.1 UC1.AN5
VSSSENSE_VGA: PRV36.1 RV43.1 RV158.2
+BIF_VDDC: CV61.1 CV62.1 CV63.1 RV31.2 UV1.R21 UV1.U21
+CCG_VBUS: CT12.1 CT15.1 CT16.1 CT17.1 CT18.1 EU7.2 EU7.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 UT1.14 UT1.15
+CHARGER_SRC: PCB20.1 PCB21.1 PCB22.1 PCB23.1 PCB24.1 PCB25.1 PCB26.1 PCB27.1 PDB13.3 PJPB01.2 PLB02.2 PQB26.5
+DCBAT_LCD: C5.1 C6.1 F1.2 JEDP1.1 JEDP1.2 JEDP1.3 RB1.1
+DP_VDDC: CV33.1 CV34.1 RV30.2 UV1.AD14
+DP_VDDR: CV26.1 CV27.1 RV27.2 UV1.AF14
+FB0_VREFCL: CV151.1 RV54.2 RV55.1 UV13.J14
+FB0_VREFDL: CV150.1 RV52.2 RV53.1 UV13.A10 UV13.U10
+FB1_VREFCL: CV172.1 RV50.2 RV51.1 UV15.J14
+FB1_VREFDL: CV171.1 RV48.2 RV49.1 UV15.A10 UV15.U10
+FP_VCC: C4.2 JFP1.7 JFP1.8 R5.2
+LAN_VDD33: CL10.1 CL11.1 CL15.1 CL17.1 JP5.1 RL4.1 RL6.1 UL1.11 UL1.32 UL2.1
+LCDVDD: R8.2 RB2.1 U1.1
+LCDVDD_LCD: C7.1 C8.1 C9.1 JEDP1.7 JEDP1.8 R8.1 RB3.1
+LINE1_VREFO_L: DA4.1 UA1.24
+MIC2-VREFO: RA25.1 RA26.1 UA1.23
+MIC_VCC: C39.1 JEDP1.26 R83.2
+MPLL_PVDD: CV81.1 CV82.1 CV83.1 LV6.2 UV1.L8
+MVREFDA: CV94.1 RV33.2 RV34.1 UV1.K26
+MVREFSA: CV95.1 RV32.2 RV35.1 UV1.J26
+PCIE_VDDC: CV54.1 CV55.1 CV56.1 CV57.1 CV58.1 CV59.1 CV60.1 RV23.2 UV1.L23 UV1.L24 UV1.L25 UV1.L26 UV1.M22 UV1.N22 UV1.N23 UV1.N24 UV1.R22 UV1.T22 UV1.U22 UV1.V22
+RTC_CELL: C1.1 D1.1 Q17.3 RA11.2 RE6.1 RE20.1 RE31.2
+RTC_CELL_VBAT: CE12.1 RE6.2 UE1.122
+RTC_PWR: D1.3 Q1.2 R1.1 R2.1
+RTC_SOC: C3.1 CC51.1 CC52.1 Q17.1 R63.1 RC77.1 RC82.1 RC87.1 UC1.BR23
+RTC_VCC: JIOB1.11 R1.2
+SPLL_PVDD: CV84.1 CV85.1 LV7.2 UV1.H7
+SPLL_VDDC: CV91.1 CV92.1 CV93.1 LV8.2 UV1.H8
+TP_VDD: C26.1 JTP1.8 Q5.1 Q8.2 R34.1 R35.1 R39.1 R42.1 R43.1 R45.1 R46.1
+TS_VDD: C37.1 JEDP1.40 R67.2 U2.1
+TS_VDD_IN: C35.1 R67.1 R81.2 R82.2 U2.5
+TSVDD: CV20.1 LV2.2 UV1.AD17
+USB2_VCC: CU17.1 JIOB1.13 JIOB1.14 JIOB1.15 JIOB1.16 UU2.1
+USB3_VCC: CU4.1 CU5.1 CU6.1 CU7.1 CU9.1 CU10.1 CU11.1 CU12.1 JUSB1.1 JUSB2.1 UU1.1
+V_DDR_REFA: CD25.1 JDIMM1.164 RD10.2 RD11.2 RD12.1
+V_DDR_REFA_R: CD27.1 RD11.1 UC1.F36
+V_DDR_REFB: CD51.1 JDIMM2.164 RD21.2 RD22.2 RD23.1
+V_DDR_REFB_R: CD52.1 RD22.1 UC1.E36
+VGA_CORE: CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV86.1 CV87.1 CV88.1 CV89.1 CV90.1 CV100.1 CV101.1 CV102.1 CV103.1 CV104.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV120.1 CV121.1 PCV171.1 PCV172.1 PLV01.1 PLV02.1 RV24.1 RV42.2 UV1.AA12 UV1.AA15 UV1.M11 UV1.M13 UV1.M15 UV1.M16 UV1.M17 UV1.M18 UV1.M20 UV1.M21 UV1.N12 UV1.N15 UV1.N17 UV1.N20 UV1.R13 UV1.R16 UV1.R18 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.U11 UV1.U13 UV1.U16 UV1.U18 UV1.V15 UV1.V17 UV1.V20 UV1.V21 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21
+VGA_CORE_TOPAZ: RV24.2 UV1.AB11 UV1.AB12 UV1.AB13 UV1.AC11 UV1.AC13 UV1.AC14 UV1.T10 UV1.U10 UV1.W9 UV1.W10 UV1.Y9
A4WP_PRESENT: RC61.2 UC1.CF17
AC_DIS: PQB31.2 PRB45.1 UE1.69
AC_PRESENT: RC66.2 RC97.2 UC1.BU35
ACIN_CHG: PCB02.1 PQB31.1 PRB09.2 PRB10.1 PUB01.16
ACLIN_CHG: PRB16.1 PRB18.1 PUB01.20
ACOK_CHG: PRB22.1 PUB01.24
ADDR_VBOOT_CPU: PRZ69.1 PUZ01.21
ADJ_2.5V: PC2505.2 PR2502.2 PR2503.1 PU2501.7
ALERT#: R54.2 U3.6
ALERT#_CPU: PRZ47.1 PUZ01.33
ALL_SYS_PWRGD: CC69.1 CC78.2 RC146.2 RC147.2 RC148.1 RE41.1 UC6.4 UC8.2
ALWON: PR506.1 UE1.121
AMBER_LED_BAT: Q2.1 R28.2
ASGATE_CHG: PRB07.2 PUB01.7
AUD_AGND: CA1.2 CA2.2 CA3.1 CA16.2 CA19.1 CA21.1 CA23.2 CA24.2 CA25.1 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 JHP1.7 RA13.1 RA16.1 RA17.1 RA18.1 RA33.2 RA34.2 RA35.2 UA1.19 UA1.31
AUD_HP1_JACK_L: RA27.1 RA28.2 UA1.25
AUD_HP1_JACK_L1: LA2.1 RA27.2 RA29.2
AUD_HP1_JACK_R: RA30.1 RA31.2 UA1.26
AUD_HP1_JACK_R1: LA3.1 RA30.2 RA32.2
AUD_PC_BEEP: CA32.2 UA1.11
AUD_PC_BEEP_C: DA3.1 RA23.1
AUD_SENSE_A: CA24.1 RA14.2 RA15.1 UA1.12
AUD_SPK_L+: RA21.1 UA1.35
AUD_SPK_L+_C: CA28.1 DA1.2 JSPK1.3 RA21.2
AUD_SPK_L-: RA22.1 UA1.36
AUD_SPK_L-_C: CA31.1 DA1.3 JSPK1.4 RA22.2
AUD_SPK_R+: RA19.1 UA1.38
AUD_SPK_R+_C: CA30.1 DA2.2 JSPK1.1 RA19.2
AUD_SPK_R-: RA20.1 UA1.37
AUD_SPK_R-_C: CA29.1 DA2.3 JSPK1.2 RA20.2
AUD_VREF: CA16.1 UA1.22
AUX_ON: RL11.2 UE1.3 UL2.4
BA_PWR: PDB01.3 PQB28.1 PRB41.2
BAT1_LED#: Q15.1 RE21.1 UE1.106
BAT2_LED#: Q15.4 RE23.1 UE1.1
BATGONE_CHG: PCB09.1 PRB23.1 PRB24.1 PUB01.25
BATT_WHITE_LED_R#: Q3.1 Q4.2 Q15.3
BEEP: DA3.3 UE1.45
BGATE_CHG: PCB28.1 PQB13.4 PUB01.32
BKLT_CTRL: D2.1 R11.1 R75.2 R79.2
BKLT_IN_EC: RC13.2 UC1.CK11 UE1.67
BLON_OUT_C: JEDP1.28 R76.2 R78.1
BLUETOOTH_EN: DW1.1 RC174.2 UC1.CP14
BLUETOOTH_EN_R: DW1.2 JWLAN1.54
BOARD_ID: CE11.1 RE1.2 RE2.2 UE1.111
BOARD_ID1: RC70.2 RC72.1 UC1.CG12
BOARD_ID2: RC69.2 RC71.1 UC1.CM14
BOOT1_CHG: PRB14.1 PUB01.12
BP_0: RV82.1 UV1.U1
BP_1: RV81.1 UV1.U3
BST1_VGA: PRV21.1 PUV01.21
BST2_VGA: PRV01.1 PUV01.30
BST_1.2V: PRM02.1 PUM01.18
BST_1.2V_R: PCM12.1 PRM02.2
BST_1.05V: PRH06.1 PUH01.1
BST_1.05V_R: PCH12.1 PRH06.2
BST_3V: PR301.1 PU301.1
BST_3V_R: PC307.1 PR301.2
BST_5V: PR501.1 PU501.1
BST_5V_R: PC507.1 PR501.2
BST_+1.35VGPU: PRW06.1 PUW01.1
BST_+1.35VGPU_R: PCW12.1 PRW06.2
BST_VCCSA: PRA01.1 PUA01.1
BST_VCCSA_R: PCA07.1 PRA01.2
BST_VCORE1: PRI01.1 PUI01.5
BST_VCORE1_R: PCI09.1 PRI01.2
BST_VCORE2: PRI21.1 PUI02.5
BST_VCORE2_R: PCI29.1 PRI21.2
BST_VGT1: PRG01.1 PUG01.5
BST_VGT1_R: PCG09.1 PRG01.2
CAM_DET#: R96.2 RC204.2 UC1.CM22
CAM_DET#_R: JEDP1.4 R96.1
CAM_EN#: TP6.1(TP-1) UC1.CE9
CAP_LED: JKB1.27 R48.2
CAP_LED#: Q9.3 R47.2 UE1.93
CAP_LED_Q: Q12.1 R48.1
CAP_LED_R#: Q9.1 Q12.2
CATERR#: RC3.2 UC1.AA4
CBN: CA17.2 UA1.28
CBP: CA17.1 UA1.30
CFG0: RC137.2 UC1.T4
CFG1: TPC11.1(TP-1) UC1.R4
CFG2: RC138.2 UC1.T3
CFG3: RC154.1 TPC12.1(TP-1) UC1.R3
CFG4: RC140.2 UC1.J4
CFG5: RC142.2 UC1.M4
CFG6: RC141.2 UC1.J3
CFG7: RC143.2 UC1.M3
CFG8: TPC13.1(TP-1) UC1.R2
CFG9: TPC14.1(TP-1) UC1.N2
CFG10: TPC15.1(TP-1) UC1.R1
CFG11: TPC16.1(TP-1) UC1.N1
CFG12: TPC17.1(TP-1) UC1.J2
CFG13: TPC18.1(TP-1) UC1.L2
CFG14: TPC19.1(TP-1) UC1.J1
CFG15: TPC20.1(TP-1) UC1.L1
CFG16: TPC21.1(TP-1) UC1.L3
CFG17: TPC23.1(TP-1) UC1.L4
CFG18: TPC22.1(TP-1) UC1.N3
CFG19: TPC24.1(TP-1) UC1.N4
CFG_A1: RT13.2 RT17.2 UT2.1
CFG_A2: RT15.2 RT19.2 UT2.13
CFG_B1: RT14.2 RT18.2 UT2.4
CFG_B2: RT16.2 RT20.2 UT2.10
CFG_RCOMP: RC139.1 UC1.AB5
CHG_AMBER_LED_R#: Q2.2 Q15.6
CLK_CNV_CRX_DTX_N: JWLAN1.21 UC1.CN31
CLK_CNV_CRX_DTX_P: JWLAN1.23 UC1.CP31
CLK_CNV_CTX_DRX_N: JWLAN1.71 UC1.CP34
CLK_CNV_CTX_DRX_P: JWLAN1.73 UC1.CN34
CLK_ITPXDP_N: TP14.1(TP-1) UC1.AU1
CLK_ITPXDP_P: TP15.1(TP-1) UC1.AU2
CLK_PCIE_N1: JWLAN1.49 UC1.BC1
CLK_PCIE_N2: UC1.BD3 UL1.16
CLK_PCIE_N4: JSSD1.53 UC1.BA1
CLK_PCIE_P1: JWLAN1.47 UC1.BC2
CLK_PCIE_P2: UC1.BC3 UL1.15
CLK_PCIE_P4: JSSD1.55 UC1.BA2
CLK_PEG_N0: UC1.AW2 UV1.AK32
CLK_PEG_P0: UC1.AY3 UV1.AK30
CLK_SMB: PBATT1.7 PR42.1
CLK_TP_SIO: C25.1 JTP1.1 R35.2 UE1.78
CLKREQ_CNV#: JWLAN1.14 RC73.2 UC1.CH29
CLKREQ_PCIE#1: RC81.2 RW8.1 UC1.CE32
CLKREQ_PCIE#1_R: JWLAN1.53 RW8.2
CLKREQ_PCIE#2: RC85.2 RL5.1 UC1.CF30
CLKREQ_PCIE#2_R: RL5.2 UL1.12
CLKREQ_PCIE#4: JSSD1.52 RC88.2 UC1.CE30
CLKREQ_PEG#0: RC78.2 RV153.1 UC1.CF32
CLKREQ_PEG#0_R: RV152.2 RV153.2 UV1.N7
CMP_STRAP0: RE94.1 UE1.118
CMP_VIN0: RE34.1 RE38.1 UE1.20
CMP_VOUT0: PR507.1 RE36.2 RE38.2 UE1.85
CMSRC_CHG: PRB08.2 PUB01.5
CNV_BRI_CRX_DTX: RC121.2 RW3.2 UC1.CK20
CNV_BRI_CRX_DTX_R: JWLAN1.22 RW3.1
CNV_BRI_CTX_DRX: RC202.2 RW7.2 UC1.CJ20
CNV_BRI_CTX_DRX_R: JWLAN1.36 RW7.1
CNV_CRX_DTX_N0: JWLAN1.15 UC1.CR30
CNV_CRX_DTX_N1: JWLAN1.9 UC1.CM30
CNV_CRX_DTX_P0: JWLAN1.17 UC1.CP30
CNV_CRX_DTX_P1: JWLAN1.11 UC1.CN30
CNV_CTX_DRX_N0: JWLAN1.65 UC1.CN32
CNV_CTX_DRX_N1: JWLAN1.59 UC1.CP33
CNV_CTX_DRX_P0: JWLAN1.67 UC1.CM32
CNV_CTX_DRX_P1: JWLAN1.61 UC1.CN33
CNV_RF_RESET#: JWLAN1.10 RC74.2 UC1.CJ32
CNV_RGI_CRX_DTX: RC122.2 RW6.2 UC1.CH19
CNV_RGI_CRX_DTX_R: JWLAN1.34 RW6.1
CNV_RGI_CTX_DRX: RC108.2 RC162.2 RW5.2 UC1.CG19
CNV_RGI_CTX_DRX_R: JWLAN1.32 RW4.1 RW5.1
CNV_WT_RCOMP: RC60.2 UC1.CP32 UC1.CR32
COMP_1A_CPU: PCZ30.1 PCZ31.1 PUZ01.26
COMP_1B_CPU: PCZ01.1 PCZ03.1 PUZ01.43
COMP_2PH_CPU: PCZ15.2 PCZ16.2 PUZ01.4
COMP_CHG: PCB12.1 PRB30.1 PUB01.28
CPU_C10_GATE#: UC1.CN27 UC9.2
CPU_DP1_CTRL_CLK: QI3.1 RC7.2 UC1.CC8
CPU_DP1_CTRL_DATA: QI3.4 RC8.2 UC1.CC9
CPU_DP1_HPD: QI2.3 RI13.2 UC1.CN6
CPU_DP1_N0: CI7.1 UC1.AL5
CPU_DP1_N1: CI5.1 UC1.AJ5
CPU_DP1_N2: CI3.1 UC1.AF6
CPU_DP1_N3: CI1.1 UC1.AE5
CPU_DP1_P0: CI8.1 UC1.AL6
CPU_DP1_P1: CI6.1 UC1.AJ6
CPU_DP1_P2: CI4.1 UC1.AF5
CPU_DP1_P3: CI2.1 UC1.AE6
CPU_DP2_AUXN: JVGA1.9 UC1.AD4
CPU_DP2_AUXP: JVGA1.8 UC1.AD3
CPU_DP2_CTRL_DATA: RC9.2 UC1.CH3
CPU_DP2_HPD: JVGA1.13 RC12.2 UC1.CM6
CPU_DP2_N0: JVGA1.3 UC1.AC4
CPU_DP2_N1: JVGA1.6 UC1.AC1
CPU_DP2_P0: JVGA1.2 UC1.AC3
CPU_DP2_P1: JVGA1.5 UC1.AC2
CPU_POPIRCOMP: RC15.1 UC1.BP27
CPU_SPI_0_CLK: RC21.2 RC187.2 UC1.CH37
CPU_SPI_0_CS#0: RC31.2 UC1.CG36 UC3.1
CPU_SPI_0_CS#1: RC207.2 UC1.CG35 UC11.1
CPU_SPI_0_CS#2: UC1.CH34 UX1.20
CPU_SPI_0_D0: RC23.2 RC35.2 UC1.CF36
CPU_SPI_0_D1: RC22.2 UC1.CF37
CPU_SPI_0_D2: RC24.2 RC36.2 UC1.CF34
CPU_SPI_0_D3: RC25.2 RC37.2 UC1.CG34
CPU_SPI_CLK: RC21.1 RC40.2 RC178.2 RX9.1
CPU_SPI_D0: RC23.1 RC32.2 RC42.2 RC180.2 RX6.1
CPU_SPI_D1: RC22.1 RC43.2 RC179.2 RX5.1
CPU_SPI_D2: RC24.1 RC39.1 RC177.1
CPU_SPI_D3: RC25.1 RC41.1 RC181.1
CPU_XDP_TCK0: RC156.1 TPC2.1(TP-1) UC1.P6 UC1.T6
CPVEE: CA18.1 UA1.27
CS_1.2V: PRM03.1 PUM01.13
CSCOMP_2PH_CPU: PCZ17.1 PCZ18.1 PHZ02.2 PRZ27.2 PRZ28.1 PUZ01.6
CSCOMP_2PH_CPU_R: PHZ02.1 PRZ26.2 PRZ27.1
CSIN_CHG: PCB03.2 PCB05.1 PRB12.2 PUB01.14
CSIP_CHG: PCB03.1 PCB04.1 PRB11.2 PUB01.15
CSN1_VCORE1: PLI01.3 PRZ31.1
CSN2_VCORE2: PLI02.3 PRZ30.1
CSN_1A_VGT: PHZ03.2 PLG01.3 PRZ51.1
CSN_1A_VGT_NTC: PHZ03.1 PRZ45.1
CSN_1B_VCCSA: PHZ01.1 PLA01.3 PRZ06.1
CSON_CHG: PCB15.2 PCB16.1 PRB37.1 PUB01.1
CSOP_CHG: PCB15.1 PCB17.1 PRB36.1 PUB01.2
CSP1_2PH_CPU: PCZ20.2 PRZ32.2 PRZ37.2 PUZ01.10
CSP1_VCORE1: PLI01.2 PRZ25.1 PRZ37.1
CSP2_2PH_CPU: PCZ21.2 PRZ33.2 PRZ38.2 PRZ39.2 PUZ01.9
CSP2_VCORE2: PLI02.2 PRZ29.1 PRZ38.1
CSP_1A_VCORE: PCZ26.1 PCZ27.1 PRZ44.2 PRZ45.2 PUZ01.29
CSP_1A_VGT_R: PLG01.2 PRZ44.1
CSP_1B_VCCSA: PCZ08.2 PCZ09.2 PRZ10.2 PRZ13.2 PUZ01.40
CSP_1B_VCCSA_R: PLA01.2 PRZ13.1
CSREF_2PH_CPU: PCZ19.1 PCZ20.1 PCZ21.1 PRZ30.2 PRZ31.2 PRZ32.1 PRZ33.1 PUZ01.8
CSSUM_2PH_CPU: PCZ17.2 PCZ18.2 PRZ25.2 PRZ26.1 PRZ29.2 PUZ01.7
DAT_SMB: PBATT1.6 PR37.1
DAT_TP_SIO: C24.1 JTP1.2 R34.2 UE1.79
DBC_PANEL_EN: R13.1 RC106.2 UC1.CA31
DBC_PANEL_EN_R: JEDP1.11 R13.2
DCIN_CHG: PCB07.1 PCB71.1 PRB15.2 PUB01.17
DDR_A_ACT#: JDIMM1.114 UC1.V35
DDR_A_ALERT#: JDIMM1.116 UC1.W37
DDR_A_BA0: JDIMM1.150 UC1.W32
DDR_A_BA1: JDIMM1.145 UC1.AB31
DDR_A_BG0: JDIMM1.115 UC1.V34
DDR_A_BG1: JDIMM1.113 UC1.W35
DDR_A_CAS#: JDIMM1.156 UC1.AB32
DDR_A_CKE0: JDIMM1.109 UC1.U36
DDR_A_CKE1: JDIMM1.110 UC1.U37
DDR_A_CKE2: TP9.1(TP-1) UC1.U34
DDR_A_CKE3: TP11.1(TP-1) UC1.U35
DDR_A_CLK0: JDIMM1.137 UC1.V31
DDR_A_CLK1: JDIMM1.138 UC1.T31
DDR_A_CLK#0: JDIMM1.139 UC1.V32
DDR_A_CLK#1: JDIMM1.140 UC1.T32
DDR_A_CS#0: JDIMM1.149 UC1.AE32
DDR_A_CS#1: JDIMM1.157 UC1.AF32
DDR_A_D0: JDIMM1.38 UC1.A26
DDR_A_D1: JDIMM1.41 UC1.D26
DDR_A_D2: JDIMM1.28 UC1.D28
DDR_A_D3: JDIMM1.25 UC1.C28
DDR_A_D4: JDIMM1.42 UC1.B26
DDR_A_D5: JDIMM1.37 UC1.C26
DDR_A_D6: JDIMM1.24 UC1.B28
DDR_A_D7: JDIMM1.29 UC1.A28
DDR_A_D8: JDIMM1.4 UC1.B30
DDR_A_D9: JDIMM1.16 UC1.D30
DDR_A_D10: JDIMM1.3 UC1.B33
DDR_A_D11: JDIMM1.20 UC1.D32
DDR_A_D12: JDIMM1.8 UC1.A30
DDR_A_D13: JDIMM1.7 UC1.C30
DDR_A_D14: JDIMM1.21 UC1.B32
DDR_A_D15: JDIMM1.17 UC1.C32
DDR_A_D16: JDIMM1.45 UC1.H37
DDR_A_D17: JDIMM1.46 UC1.H34
DDR_A_D18: JDIMM1.58 UC1.K34
DDR_A_D19: JDIMM1.63 UC1.K35
DDR_A_D20: JDIMM1.50 UC1.H36
DDR_A_D21: JDIMM1.49 UC1.H35
DDR_A_D22: JDIMM1.59 UC1.K36
DDR_A_D23: JDIMM1.62 UC1.K37
DDR_A_D24: JDIMM1.67 UC1.N36
DDR_A_D25: JDIMM1.70 UC1.N34
DDR_A_D26: JDIMM1.79 UC1.R37
DDR_A_D27: JDIMM1.84 UC1.R34
DDR_A_D28: JDIMM1.71 UC1.N37
DDR_A_D29: JDIMM1.66 UC1.N35
DDR_A_D30: JDIMM1.83 UC1.R36
DDR_A_D31: JDIMM1.80 UC1.R35
DDR_A_D32: JDIMM1.174 UC1.AN35
DDR_A_D33: JDIMM1.170 UC1.AN34
DDR_A_D34: JDIMM1.182 UC1.AR35
DDR_A_D35: JDIMM1.186 UC1.AR34
DDR_A_D36: JDIMM1.169 UC1.AN37
DDR_A_D37: JDIMM1.173 UC1.AN36
DDR_A_D38: JDIMM1.183 UC1.AR36
DDR_A_D39: JDIMM1.187 UC1.AR37
DDR_A_D40: JDIMM1.194 UC1.AU35
DDR_A_D41: JDIMM1.195 UC1.AU34
DDR_A_D42: JDIMM1.207 UC1.AW35
DDR_A_D43: JDIMM1.190 UC1.AW34
DDR_A_D44: JDIMM1.203 UC1.AU37
DDR_A_D45: JDIMM1.191 UC1.AU36
DDR_A_D46: JDIMM1.208 UC1.AW36
DDR_A_D47: JDIMM1.204 UC1.AW37
DDR_A_D48: JDIMM1.211 UC1.BA35
DDR_A_D49: JDIMM1.216 UC1.BA34
DDR_A_D50: JDIMM1.229 UC1.BC35
DDR_A_D51: JDIMM1.228 UC1.BC34
DDR_A_D52: JDIMM1.215 UC1.BA37
DDR_A_D53: JDIMM1.212 UC1.BA36
DDR_A_D54: JDIMM1.224 UC1.BC36
DDR_A_D55: JDIMM1.225 UC1.BC37
DDR_A_D56: JDIMM1.232 UC1.BE35
DDR_A_D57: JDIMM1.233 UC1.BE34
DDR_A_D58: JDIMM1.250 UC1.BG35
DDR_A_D59: JDIMM1.246 UC1.BG34
DDR_A_D60: JDIMM1.237 UC1.BE37
DDR_A_D61: JDIMM1.236 UC1.BE36
DDR_A_D62: JDIMM1.245 UC1.BG36
DDR_A_D63: JDIMM1.249 UC1.BG37
DDR_A_DQS0: JDIMM1.34 UC1.D27
DDR_A_DQS1: JDIMM1.13 UC1.C31
DDR_A_DQS2: JDIMM1.55 UC1.J34
DDR_A_DQS3: JDIMM1.76 UC1.P35
DDR_A_DQS4: JDIMM1.179 UC1.AP34
DDR_A_DQS5: JDIMM1.200 UC1.AV35
DDR_A_DQS6: JDIMM1.221 UC1.BB34
DDR_A_DQS7: JDIMM1.242 UC1.BF35
DDR_A_DQS#0: JDIMM1.32 UC1.C27
DDR_A_DQS#1: JDIMM1.11 UC1.D31
DDR_A_DQS#2: JDIMM1.53 UC1.J35
DDR_A_DQS#3: JDIMM1.74 UC1.P34
DDR_A_DQS#4: JDIMM1.177 UC1.AP35
DDR_A_DQS#5: JDIMM1.198 UC1.AV34
DDR_A_DQS#6: JDIMM1.219 UC1.BB35
DDR_A_DQS#7: JDIMM1.240 UC1.BF34
DDR_A_MA0: JDIMM1.144 UC1.AC37
DDR_A_MA1: JDIMM1.133 UC1.AC36
DDR_A_MA2: JDIMM1.132 UC1.AC34
DDR_A_MA3: JDIMM1.131 UC1.AC35
DDR_A_MA4: JDIMM1.128 UC1.AA35
DDR_A_MA5: JDIMM1.126 UC1.AB35
DDR_A_MA6: JDIMM1.127 UC1.AA37
DDR_A_MA7: JDIMM1.122 UC1.AA36
DDR_A_MA8: JDIMM1.125 UC1.AB34
DDR_A_MA9: JDIMM1.121 UC1.W36
DDR_A_MA10: JDIMM1.146 UC1.Y31
DDR_A_MA11: JDIMM1.120 UC1.W34
DDR_A_MA12: JDIMM1.119 UC1.AA34
DDR_A_MA13: JDIMM1.158 UC1.AC32
DDR_A_ODT0: JDIMM1.155 UC1.AE31
DDR_A_ODT1: JDIMM1.161 UC1.AF31
DDR_A_PAR: JDIMM1.143 UC1.W31
DDR_A_RAS#: JDIMM1.152 UC1.Y32
DDR_A_WE#: JDIMM1.151 UC1.AC31
DDR_B_ACT#: JDIMM2.114 UC1.W28
DDR_B_ALERT#: JDIMM2.116 UC1.Y29
DDR_B_BA0: JDIMM2.150 UC1.AJ37
DDR_B_BA1: JDIMM2.145 UC1.AJ36
DDR_B_BG0: JDIMM2.115 UC1.W29
DDR_B_BG1: JDIMM2.113 UC1.Y28
DDR_B_CAS#: JDIMM2.156 UC1.AK34
DDR_B_CKE0: JDIMM2.109 UC1.T28
DDR_B_CKE1: JDIMM2.110 UC1.T29
DDR_B_CKE2: TP10.1(TP-1) UC1.V28
DDR_B_CKE3: TP12.1(TP-1) UC1.V29
DDR_B_CLK0: JDIMM2.137 UC1.AF29
DDR_B_CLK1: JDIMM2.138 UC1.AE29
DDR_B_CLK#0: JDIMM2.139 UC1.AF28
DDR_B_CLK#1: JDIMM2.140 UC1.AE28
DDR_B_CS#0: JDIMM2.149 UC1.AL37
DDR_B_CS#1: JDIMM2.157 UC1.AL35
DDR_B_D0: JDIMM2.28 UC1.J22
DDR_B_D1: JDIMM2.37 UC1.H25
DDR_B_D2: JDIMM2.29 UC1.G22
DDR_B_D3: JDIMM2.24 UC1.H22
DDR_B_D4: JDIMM2.42 UC1.F25
DDR_B_D5: JDIMM2.38 UC1.J25
DDR_B_D6: JDIMM2.41 UC1.G25
DDR_B_D7: JDIMM2.25 UC1.F22
DDR_B_D8: JDIMM2.8 UC1.D22
DDR_B_D9: JDIMM2.7 UC1.C22
DDR_B_D10: JDIMM2.21 UC1.C24
DDR_B_D11: JDIMM2.20 UC1.D24
DDR_B_D12: JDIMM2.3 UC1.A22
DDR_B_D13: JDIMM2.4 UC1.B22
DDR_B_D14: JDIMM2.16 UC1.A24
DDR_B_D15: JDIMM2.17 UC1.B24
DDR_B_D16: JDIMM2.45 UC1.G31
DDR_B_D17: JDIMM2.46 UC1.G32
DDR_B_D18: JDIMM2.62 UC1.H29
DDR_B_D19: JDIMM2.58 UC1.H28
DDR_B_D20: JDIMM2.50 UC1.G28
DDR_B_D21: JDIMM2.49 UC1.G29
DDR_B_D22: JDIMM2.63 UC1.H31
DDR_B_D23: JDIMM2.59 UC1.H32
DDR_B_D24: JDIMM2.71 UC1.L31
DDR_B_D25: JDIMM2.66 UC1.L32
DDR_B_D26: JDIMM2.79 UC1.N29
DDR_B_D27: JDIMM2.84 UC1.N28
DDR_B_D28: JDIMM2.70 UC1.L28
DDR_B_D29: JDIMM2.67 UC1.L29
DDR_B_D30: JDIMM2.83 UC1.N31
DDR_B_D31: JDIMM2.80 UC1.N32
DDR_B_D32: JDIMM2.170 UC1.AJ29
DDR_B_D33: JDIMM2.173 UC1.AJ30
DDR_B_D34: JDIMM2.183 UC1.AM32
DDR_B_D35: JDIMM2.187 UC1.AM31
DDR_B_D36: JDIMM2.186 UC1.AM30
DDR_B_D37: JDIMM2.182 UC1.AM29
DDR_B_D38: JDIMM2.169 UC1.AJ31
DDR_B_D39: JDIMM2.174 UC1.AJ32
DDR_B_D40: JDIMM2.191 UC1.AR31
DDR_B_D41: JDIMM2.190 UC1.AR32
DDR_B_D42: JDIMM2.204 UC1.AV30
DDR_B_D43: JDIMM2.208 UC1.AV29
DDR_B_D44: JDIMM2.195 UC1.AR30
DDR_B_D45: JDIMM2.194 UC1.AR29
DDR_B_D46: JDIMM2.207 UC1.AV32
DDR_B_D47: JDIMM2.203 UC1.AV31
DDR_B_D48: JDIMM2.212 UC1.BA32
DDR_B_D49: JDIMM2.211 UC1.BA31
DDR_B_D50: JDIMM2.225 UC1.BD31
DDR_B_D51: JDIMM2.229 UC1.BD32
DDR_B_D52: JDIMM2.215 UC1.BA30
DDR_B_D53: JDIMM2.216 UC1.BA29
DDR_B_D54: JDIMM2.228 UC1.BD29
DDR_B_D55: JDIMM2.224 UC1.BD30
DDR_B_D56: JDIMM2.233 UC1.BG31
DDR_B_D57: JDIMM2.232 UC1.BG32
DDR_B_D58: JDIMM2.249 UC1.BK32
DDR_B_D59: JDIMM2.245 UC1.BK31
DDR_B_D60: JDIMM2.236 UC1.BG29
DDR_B_D61: JDIMM2.237 UC1.BG30
DDR_B_D62: JDIMM2.250 UC1.BK30
DDR_B_D63: JDIMM2.246 UC1.BK29
DDR_B_DQS0: JDIMM2.34 UC1.G24
DDR_B_DQS1: JDIMM2.13 UC1.D23
DDR_B_DQS2: JDIMM2.55 UC1.H30
DDR_B_DQS3: JDIMM2.76 UC1.N30
