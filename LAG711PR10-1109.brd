# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3D3_STB: length 7
  TOP w0.112: RA11.1 v2(28.72,20.43)
  TOP w0.203: UA1.16 31.46,15.98 31.38,16.06 31.38,16.44 31.35,16.47
  TOP w0.254: 31.35,16.47 31.35,16.98 31.12,17.2 31.12,19.58 30.64,20.06 30.64,20.3 RA9.1 RA11.1
VBAT_CHG: length 4.7
  TOP w0.112: PCB14.1 208.75,42.78 v2(208.91,42.62)
  TOP w0.254: v1(207.7,44.31) 208.39,43.62 PCB14.1
  BOTTOM w0.203: PUB01.31 207.5,44.52 207.7,44.32 v1(207.7,44.31) 208.48,44.31 PRB35.2
VCC_CPU: length 5.6
  BOTTOM w0.112: PRZ57.2 171.85,50.22 170.84,49.22 v2(170.67,49.22)
  BOTTOM w0.203: PUZ01.13 172.04,53.7 171.87,53.53 171.87,52.76 171.93,52.7 PCZ34.1 171.94,51.23 PRZ57.2
VCC_GT_SENSE: length 63.5
  TOP w0.112: PRZ59.1 v2(169.71,63.95)
  TOP w0.254: v1(170.72,64.85) PRZ59.1
  IN1 w0.254: v1(170.72,64.85) 170.15,65.42 170.15,70.79 166.13,74.8 154.22,74.8 147.35,81.67 147.35,86.29 145.46,88.19 145.25,88.4 145.25,93.58 145.71,94.04 146.28,94.04 v1(146.41,94.17)
  BOTTOM w0.076: 136.5,92.32 136.5,92.1 136.23,91.83 136.23,91.75 136.22,91.75 136.22,91.37 136.06,91.2 135.68,91.2 135.24,90.76 UC1.E3
  BOTTOM w0.254: 136.5,92.32 136.5,92.45 138.53,94.48 139.62,94.48 RC169.2 141.08,94.72 141.64,94.17 v1(146.41,94.17)
VCC_VCORE1: length 4.2
  TOP w0.112: PRI02.2 v2(160.18,66.47)
  TOP w0.254: PRI02.2 161.53,66.64 PCI10.1 162.53,66.88 v1(163.02,67.37)
  BOTTOM w0.254: PUI01.3 v1(163.02,67.37)
VCC_VCORE2: length 4.2
  BOTTOM w0.112: PRI22.2 169.15,88.73 v2(168.69,89.19)
  BOTTOM w0.254: PRI22.2 168.23,87.31 PCI30.1 167.67,86.71 167.67,86.64 167.55,86.52 PUI02.3
VCC_VGT1: length 3.5
  TOP w0.112: PRG02.2 v2(159.78,95.16)
  TOP w0.254: PRG02.2 158.7,95.87 v1(158.85,96.02)
  BOTTOM w0.254: PUG01.3 158.84,96 v1(158.85,96.02) 158.99,96.15 PCG10.1
VCCDPHY_1P24: length 9.3
  TOP w0.508: RC133.2 122.53,54.58 v2(122.53,52.98) 122.16,52.62 122.16,51.55 122.38,51.33 122.38,49.17 122.01,48.8 122,48.8 121.7,48.5 CC58.1 121.31,48.23 v1(121.31,47.4)
  BOTTOM w0.203: v1(121.31,47.4) 121.45,47.54 UC1.CP25
VCCDSW_EN: length 84.7
  TOP w0.112: UE1.88 40.55,84.94 v1(40.19,85.3) RE58.2 ; v1(69.25,29.22) v2(69.25,28.04)
  TOP w0.254: v1(69.25,29.22) 69.41,29.05 DZ2.2 70.48,29.52 RZ8.1
  IN2 w0.124: v1(69.25,29.22) 69.24,29.22 65.87,29.22 65.26,28.61 61.99,28.61 60.76,29.85 60.29,29.85 55.15,34.99 50.87,34.99 46.4,39.45 46.4,47.32 48.2,49.12 48.2,54.33 46.74,55.79 46.74,58.79 42.55,62.97 42.55,63.78 40.8,65.53 40.8,67.24 40.98,67.42 40.98,78.93 39.85,80.06 39.85,83.5 40.48,84.13 40.48,85.01 v1(40.19,85.3)
VCCGT_B+: length 4.4
  BOTTOM w0.254: RB7.2 157.26,99.5 157.51,99.25 160.2,99.25 PLG11.2
  vias: v1(162.83,94.91) v1(162.83,94.28) v1(163.41,94.91) v1(163.41,94.28) v1(164.02,94.91) v1(164.02,94.28) v3(164.59,94.57)
VCCIO_SENSE: length 1.2
  TOP w0.112: v1(119.24,59.84) 119.64,60.24 TP30.1
  BOTTOM w0.089: v1(119.24,59.84) 119.24,59.83 UC1.BP28
VCCSA_B+:
  vias: v1(163.78,56.27) v1(164.36,56.27) v1(164.94,56.27) v1(165.53,56.27) v3(165.59,57.42)
VCCSENSE: length 71.5
  TOP w0.254: v1(133.42,72.62) 133.42,72.42 133.67,72.16 134.31,72.16 134.53,71.94 138.14,71.94 138.63,72.43 144.14,72.43 RC167.2 144.48,72.45 145.7,72.45 146.66,71.5 146.66,70.67 147.34,69.99 148.23,69.99 v1(148.37,69.85) ; PRZ14.1 182.86,53.53 183.42,52.97 v1(183.42,52.95)
  IN3 w0.254: v1(148.37,69.85) 148.45,69.92 148.76,69.92 149.89,71.05 150.85,71.05 151.61,71.81 160.86,71.81 162.84,69.83 172.65,69.83 180.04,62.44 181.93,62.44 183.05,61.32 183.05,61.09 183.42,60.72 183.42,59.83 185.77,57.48 185.77,53.65 184.95,52.83 183.55,52.83 v1(183.42,52.95)
  BOTTOM w0.2: UC1.AN6 133.27,72.92 v1(133.42,72.62)
VCCSENSE_VGA: length 77.1
  TOP w0.254: PRV34.1 76.71,123.57 76.96,123.82 76.96,123.95 77,123.98 v1(77,123.98) ; v1(92.27,119.05) 92.43,119.2 92.43,119.63 92.87,120.07 94.14,120.07 94.55,119.67 97.16,119.67 97.48,119.99 100.17,119.99 v2(100.52,120.34) 100.56,120.34 103.29,123.07 103.29,126.11 105.7,128.52 105.7,132.47 103.82,134.35 103.82,138.39 104.52,139.09 109.13,139.09 109.42,139.37 109.42,143.35 111.74,145.68 114.13,145.68 115.03,144.78 115.03,142.43 115.4,142.06 115.4,141.11 115.28,140.98 115.28,140.51 115.67,140.11 116.34,140.11 RV159.2 117.72,138.74 117.72,137.97 118.02,137.66 118.17,137.66 118.17,137.66 118.57,137.66 118.57,137.66 RV42.1
  IN2 w0.254: v1(77,123.98) 77,122.58 78.64,120.94 83.37,120.94 84.76,119.55 88.84,119.55 89.16,119.87 90.02,119.87 90.46,120.31 91.48,120.31 92.27,119.51 v1(92.27,119.05)
VCCST_PWRGD: length 7.8
  BOTTOM w0.102: UC1.BJ2 136.03,63.64 136.13,63.74 136.13,63.94 136,64.07 136,64.37 136.1,64.47 136.51,64.47 136.61,64.37 136.61,64.12 136.71,64.02 137.04,64.02 137.14,64.12 137.14,64.57 138.07,65.5 138.21,65.5 138.38,65.32 138.38,65.18 137.56,64.36 137.56,64.12 137.67,64.02 137.96,64.02 RC99.2
VCCSTG_IO_EN: length 230
  TOP w0.112: RZ10.1 92.61,58.28 91.03,56.7 88.55,56.7 v1(88.3,56.45) v2(88.3,54.8) 88.3,48.76 91.66,45.4 93.02,45.4 93.63,46.01 v1(93.63,46.04) 93.63,46.41 93.09,46.95 93.09,49.2 92.77,49.53 92.77,51.45 93.19,51.87 RZ2.2 94.79,52.27 UC9.4 ; RZ3.1 155.34,41.13 DZ6.1 156.63,39.85 v1(156.63,36.81)
  IN2 w0.124: v1(85.84,31.94) 85.84,32.52 86.17,32.86 94.17,32.86 95.59,34.28 117.71,34.28 119.56,36.13 119.88,36.13 120.29,35.73 130.67,35.73 131.96,37.02 135.48,37.02 136.02,36.48 138.8,36.48 142.01,39.68 142.97,39.68 144.37,38.29 146.75,38.29 147.03,38 152.07,38 153.69,36.38 156.19,36.38 v1(156.63,36.81)
  BOTTOM w0.112: v1(93.63,46.04) 93.91,46.04 94.46,46.6 95.23,46.6 95.49,46.34 95.49,44.49 94.62,43.62 94.51,43.51 92.76,43.51 92.23,42.98 91.98,42.98 90.33,41.34 88.21,39.22 86.89,39.22 86.76,39.08 84.52,39.08 83.47,38.03 83.47,37.4 85.12,35.75 85.12,32.66 v1(85.84,31.94) ; v1(88.3,56.45) 88.81,55.94 91.7,55.94 99.68,63.92 99.68,100.62 106.25,107.18 114.24,107.18 116.97,104.45 119.68,104.45 122.67,101.47 128.02,101.47 130.4,103.84 130.4,104.95 CZ4.1 129.83,105.09 128.7,106.21 UZ1.5
VCCSTG_IO_EN_R: length 5.7
  TOP w0.112: v2(157.43,41.64) 157.01,42.06 DZ6.2 156.11,42.05 RZ3.2 154.06,41.13 CZ11.1 153.92,41.17 UZ2.4
VDD10: length 12.5
  TOP w0.127: v2(20.37,87.85) 20.51,87.71 v1(21.03,87.71)
  TOP w0.203: v1(23.73,85.63) 23.6,85.5 UL1.22 ; UL1.3 v1(23.6,78.85) ; v1(20.9,81.45) 21.28,81.45 21.49,81.66 UL1.30 ; UL1.8 25.6,78.9 v1(25.54,78.84)
  TOP w0.305: CL16.1 23.66,85.71 v1(23.73,85.63)
  IN3 w1.016: 21.52,86.58 21.73,86.37 21.73,81.81
  BOTTOM w0.305: CL4.1 23.66,85.56 v1(23.73,85.63)
  vias: v1(20.89,80.86) v1(21.62,87.71)
VDD_1.2V: length 10.5
  TOP w0.508: PRM03.2 37.52,23.87 35.72,23.87 34.98,23.13 34.98,22.94 34.42,22.37 32.08,22.37 v2(31.4,23.05) 30.87,23.58 30.87,24.77 31.38,25.28 PCM14.1
VDD_CHG: length 19.8
  TOP w0.254: PRB25.1 PRB44.1 204.25,49 PCB08.2 203.37,48.83 v1(202.85,48.83) 202.55,49.13 202.55,49.55 202.95,49.95 203.34,49.95 v2(203.37,49.98) 203.55,50.16 203.55,50.55 204.12,51.11 204.24,51.11 204.29,51.15 204.79,51.15 v1(204.84,51.1)
  IN1 w0.254: v1(200.44,40.94) 200.44,47.3 201.46,48.32 202.35,48.32 v1(202.85,48.83)
  BOTTOM w0.203: PUB01.18 203.63,48.37 203.17,48.83 v1(202.85,48.83)
  BOTTOM w0.254: PRB39.2 PRB27.1 v1(200.44,40.94) ; PRB18.2 204.89,50.9 204.84,50.95 v1(204.84,51.1)
VDDIO_VGA: length 4
  TOP w0.203: PUV01.6 71.01,129.5 v2(70.51,130) 70.49,130.02 69.7,130.02 PCV10.1 69.55,130.16 68.83,130.16 PRV14.2 PRV12.2
VDDP_1.2V: length 2.8
  TOP w0.112: v2(34.21,22.88) 34.57,23.24 34.57,24.68 PRM05.1
VDDP_CHG: length 3.9
  BOTTOM w0.112: v2(201.43,42.86) 201.9,42.39 PRB39.1
  BOTTOM w0.203: PUB01.8 203.23,43.11 202.73,42.6 PCB19.1 PRB39.1
VDDR4: length 2.1
  BOTTOM w0.381: UV1.Y12 121.47,129.87 122.21,129.87 UV1.V12 UV1.U12
VDDREG: length 0.7
  TOP w0.127: v2(22.78,86.3) 22.98,86.1 v1(22.98,85.67)
  vias: v1(22.97,85.09)
VSS_GT_SENSE: length 62.8
  TOP w0.112: v1(170.91,65.4) 170.68,65.63 v2(170.32,65.63)
  TOP w0.254: PRZ53.2 171.53,64.72 170.91,65.34 v1(170.91,65.4)
  IN1 w0.254: v1(170.91,65.4) 170.76,65.4 170.51,65.65 170.51,70.94 166.28,75.16 154.37,75.16 147.71,81.82 147.71,86.44 145.6,88.55 145.6,93.43 145.86,93.68 146.31,93.68 v1(146.41,93.58)
  BOTTOM w0.102: 136.81,90.74 136.43,90.74 135.87,90.17 135.73,90.17 135.54,90.36 135.54,90.56 UC1.D2
  BOTTOM w0.254: 136.81,90.74 137.45,91.37 137.45,92.83 138.72,94.1 139.68,94.1 RC170.1 140.18,94.24 140.24,94.24 140.27,94.28 140.9,94.28 141.45,93.72 146.27,93.72 v1(146.41,93.58)
VSS_MECH: length 62.2
  TOP w0.254: v1(127.14,144.69) 127.64,144.69 v2(128.04,145.09) 130.41,147.45 134.46,147.45 134.71,147.2 v1(134.71,144.91) ; v1(111.41,120.33) 110.91,120.33 107.86,123.38 107.86,125.28 106.78,126.36 106.78,131.95 108.16,133.33 108.16,136.95 110.13,138.92 110.13,142.54 v1(111.97,144.38)
  IN1 w0.254: v1(111.97,144.38) 111.97,144.86 114.01,146.9 120.45,146.9 121.75,145.6 126.22,145.6 v1(127.14,144.69)
  BOTTOM w0.254: UV1.AM32 112.35,144.2 112.16,144.38 v1(111.97,144.38) ; v1(134.71,144.91) 134.71,144.37 UV1.A32 ; v1(111.41,120.33) 111.41,121.9 112.11,122.6 UV1.AM1
VSSIO_SENSE: length 1.1
  TOP w0.112: TP31.1 118.33,60.11 v1(118.61,59.84)
  BOTTOM w0.089: v1(118.61,59.84) 118.61,59.83 UC1.BP29
VSSSENSE: length 71
  TOP w0.254: v1(148.37,70.43) 148.31,70.37 147.53,70.37 147.04,70.86 147.04,71.65 v2(146.55,72.14) 145.86,72.83 144.48,72.83 RC168.1 144.13,72.83 138.46,72.83 137.97,72.34 134.66,72.34 134.38,72.62 v1(134.02,72.62) ; v1(182.79,52.95) 182.48,52.65 PRZ18.1
  IN3 w0.254: v1(148.37,70.43) 148.64,70.43 149.64,71.43 150.59,71.43 151.42,72.26 160.94,72.26 162.99,70.21 172.77,70.21 180.19,62.8 182.08,62.8 183.41,61.47 183.41,61.24 183.78,60.87 183.78,59.98 186.15,57.6 186.15,53.49 185.1,52.45 183.23,52.45 182.79,52.89 v1(182.79,52.95)
  BOTTOM w0.2: UC1.AN5 134.03,72.66 v1(134.02,72.62)
VSSSENSE_VGA: length 72.3
  TOP w0.254: v1(92.86,119.05) 92.8,119.1 92.8,119.46 93.05,119.72 93.99,119.72 94.4,119.31 97.31,119.31 97.63,119.63 99.3,119.63 RV43.1 99.78,119.63 100.35,119.63 103.67,122.94 103.67,125.92 106.08,128.33 106.08,132.59 104.17,134.5 104.17,138.23 104.67,138.73 109.28,138.73 109.77,139.22 109.77,143.2 111.9,145.32 113.98,145.32 114.67,144.63 114.67,142.58 114.49,142.4 v2(114.49,142.12) 114.49,140.79 115.52,139.76 115.99,139.76 116.31,139.44 RV158.2 ; v1(77.57,123.82) PRV36.1
  IN2 w0.254: v1(92.86,119.05) 92.86,119.42 92.63,119.65 92.63,119.66 91.25,121.04 90.51,121.04 90.08,120.61 84.21,120.61 83.47,121.34 78.74,121.34 77.35,122.73 77.35,123.61 v1(77.57,123.82)
+BIF_VDDC: length 1.5
  BOTTOM w0.381: UV1.R21 125.14,136.82 124.69,137.27 v1(124.54,137.27) ; v1(123.76,137.3) 123.34,136.89 UV1.U21
  vias: v1(122.13,142.19) v1(122.97,142.25) v1(123.68,142.22) v2(122.59,141.87)
+CCG_VBUS: length 4.5
  TOP w0.127: v1(31.21,120.77) v3(31.99,120.77)
  TOP w0.279: JUSBC1.B4 6.18,120.07 6.36,119.89 6.64,119.89 ; v1(8.37,122.46) 8.11,122.46 7.97,122.32 JUSBC1.A4 6.99,122.32 6.74,122.57 JUSBC1.B9
  vias: v1(8.51,119.76) v1(8.95,122.59) v1(9.09,119.76) v1(9.53,122.59) v1(9.68,119.76) v1(30.07,121.09) v1(30.07,120.45) v1(30.07,119.82) v1(30.58,121.41) v1(30.58,120.77) v1(30.58,120.14) v1(31.21,120.14)
+CHARGER_SRC: length 10
  TOP w0.508: PDB13.3 184.49,48.59 186.22,46.86 193.07,46.86
  vias: v1(193.46,46.35) v1(194.09,46.99) v1(194.09,46.35) v3(193.46,45.72)
+DCBAT_LCD: length 3.3
  TOP w0.127: v3(216.15,61.57) 215.26,61.57 C6.1
  TOP w0.381: RB1.1 210.1,58.34 210.1,59.19 v1(210.16,59.24)
  vias: v1(210.66,59.56) v1(210.66,58.92) v1(213.66,60.45) v1(213.66,59.81) v1(213.66,59.18) v3(209.48,59.47) v3(211.22,60.79)
+DP_VDDC:
  vias: v1(117.5,131.02) v3(115.24,128.19)
+DP_VDDR: length 0.6
  BOTTOM w0.305: v1(116.26,131) 116.14,131.12 UV1.AF14
  vias: v3(114.22,130.53)
+FB0_VREFCL: length 5.7
  BOTTOM w0.127: v2(152.34,149.98) RV54.2
  BOTTOM w0.254: UV13.J14 154.64,147.19
  BOTTOM w0.381: RV54.2 154.59,149.98 RV55.1 CV151.1 154.64,147.19
+FB0_VREFDL: length 22
  TOP w0.112: RV52.2 164.36,145.63 v3(165.27,145.63)
  TOP w0.356: RV52.2 163.98,145.25 CV150.1 RV53.1
  TOP w0.508: v1(163.33,143.5) RV53.1
  IN1 w0.381: v1(163.33,143.5) 161.37,141.54 150.71,141.54 v1(149.14,143.11)
  BOTTOM w0.254: UV13.A10 161.61,143.43 162.7,143.43 162.78,143.5 v1(163.33,143.5) ; UV13.U10 148.73,143.53 v1(149.14,143.11)
+FB1_VREFCL: length 5.3
  BOTTOM w0.14: RV51.1 154.48,132.01 v2(154.2,132.29)
  BOTTOM w0.254: RV51.1 155.11,131.89 UV15.J14
  BOTTOM w0.381: RV51.1 CV172.1 RV50.2
+FB1_VREFDL: length 18.8
  TOP w0.102: RV48.2 v2(161.27,122.69)
  TOP w0.381: v1(161.15,126.14) 161.11,126.11 CV171.1 161.27,125.24 RV49.1 RV48.2
  IN1 w0.381: v1(161.15,126.14) 159.93,124.93 151.15,124.93 150.53,125.55 149.65,125.55 148.31,126.89 v1(148.31,126.91)
  BOTTOM w0.254: UV15.A10 v1(161.15,126.14) ; UV15.U10 v1(148.31,126.91)
+FP_VCC: length 8
  TOP w0.127: C4.2 v3(214.97,30.42)
  TOP w0.508: C4.2 216.25,30.64 v1(216.72,31.11)
  IN1 w0.508: v1(221.52,31.94) 221.26,31.67 220.49,31.67 219.93,31.11 v1(216.72,31.11)
  BOTTOM w0.508: R5.2 v1(221.52,31.94)
+LAN_VDD33:
  vias: v1(16.26,84.82) v1(16.87,84.82) v1(20.27,84.39) v1(20.76,84.04) v1(21.31,79.56) v1(21.31,78.98) v1(27.36,81.33) v1(27.82,80.91) v3(17.13,85.35)
+LCDVDD: length 1.2
  TOP w0.127: 216.71,56.38 v3(216.71,55.22)
+LCDVDD_LCD: length 5.9
  TOP w0.127: v3(211.26,58.83) 211.51,58.58 212.33,58.58 212.63,58.28 ; v3(210.7,57.08) 210.7,57.4 211.5,58.2 212.29,58.2 C7.1 212.91,57.86 212.91,58.86 v3(213.04,58.99)
  vias: v1(213.58,57.91) v1(213.58,57.27) v1(213.58,56.64)
+LINE1_VREFO_L: length 12.9
  TOP w0.112: v1(19.53,12.25) 18.28,12.25 v2(17.78,11.75)
  TOP w0.203: UA1.24 28.01,13.61
  TOP w0.254: v1(27.47,13.71) 27.91,13.71 28.01,13.61 ; DA4.1 v1(19.53,12.25)
  IN1 w0.254: v1(27.47,13.71) 25.18,13.71 23.53,12.06 20.67,12.06 20.48,12.25 v1(19.53,12.25)
+MIC2-VREFO: length 11.8
  TOP w0.203: v1(28.2,14.13) 28.32,14.01 UA1.23
  BOTTOM w0.112: v1(19.4,13.33) v2(18.32,14.41)
  BOTTOM w0.508: v1(19.4,13.33) 19.85,13.77 22.7,13.77 23.34,14.41 27.92,14.41 v1(28.2,14.13)
+MIC_VCC: length 3.3
  TOP w0.112: v2(213.41,48.34) 213.37,48.31 v1(213.37,47.84)
  TOP w0.381: R83.2 212.76,46.5 C39.1 212.96,47.21 213.37,47.62 v1(213.37,47.84)
  BOTTOM w0.254: JEDP1.26 213.25,47.95 v1(213.37,47.84)
+MPLL_PVDD: length 1.2
  TOP w0.102: v1(128.43,126.22) 128.75,125.9 v2(128.87,125.9)
  BOTTOM w0.381: UV1.L8 128.05,126.6 v1(128.43,126.22)
+MVREFDA: length 9.2
  TOP w0.102: v1(129.24,141.4) v2(129.24,140.67)
  IN1 w0.508: v1(128.88,145.21) 127.87,144.2 127.87,143.13 128.09,142.9 128.1,142.9 128.83,142.17 128.83,141.82 v1(129.24,141.4)
  BOTTOM w0.254: v1(129.24,141.4) 128.94,141.1 UV1.K26
  BOTTOM w0.508: RV34.1 RV33.2 130.45,146.43 CV94.1 129.71,146.05 v1(128.88,145.21)
+MVREFSA: length 11
  TOP w0.254: 130.72,143.49 130.72,141.96 v1(130.21,141.45)
  TOP w0.508: 130.72,143.49 130.72,144.97 v3(132.3,146.55) 132.37,146.62 133.19,146.62 v1(133.36,146.45)
  BOTTOM w0.254: v1(130.21,141.45) 130.19,141.45 UV1.J26
  BOTTOM w0.356: CV95.1 RV35.1
  BOTTOM w0.508: RV35.1 134.4,147.38 134.23,147.55 134.2,147.55 134.17,147.58 133.69,147.58 133.49,147.38 RV32.2 133.33,146.47 v1(133.36,146.45)
+PCIE_VDDC: length 11.9
  BOTTOM w0.381: UV1.R22 v1(124.92,138.38) 124.34,137.8 UV1.T22 124.14,137.93 v1(123.74,138.33) UV1.U22 UV1.V22 v1(122.54,138.4) ; v1(127.42,141.28) 127.66,141.28 UV1.L26 ; UV1.M22 UV1.N22 v1(126.14,139) 126.48,138.86 UV1.N23 127.19,139.05 v1(127.21,139.05) 127.49,139.05 UV1.L23 ; v1(127.42,140.45) 127.69,140.45 UV1.L25 ; UV1.N24 127.11,139.76 v1(127.17,139.76) 127.57,139.76 UV1.L24
  vias: v3(126.58,139.8)
+RTC_CELL: length 116.7
  TOP w0.254: v1(29.69,22.03) 29.69,26.1 30.87,27.28 30.87,33.33 35.36,37.82 38.43,37.82 39.85,39.24 48.35,39.24 48.61,39.49 v3(48.69,39.49) v1(49.25,39.49) ; RE20.1 RE31.2 31.38,66.76 31.11,66.76 30.64,66.29 RE6.1 30.06,66.94 v1(30.13,67.01)
  TOP w0.508: v1(29.69,22.03) RA11.2
  IN1 w0.254: v1(23.71,61.96) 22.75,61.01 22.75,59.17 21.26,57.67 21.26,53.52 20.46,52.73 20.46,50.9 19.93,50.38 19.93,44.78 20.54,44.17 20.54,42.45 19.43,41.33 19.43,32.36 18.2,31.12 18.2,26.47 21.62,23.05 28.67,23.05 v1(29.69,22.03)
  IN2 w0.254: v1(49.25,39.49) 52.1,36.63 56.7,36.63 57.65,35.69 57.65,35.04 60.83,31.86 65.3,31.86 v1(65.63,32.19)
  IN3 w0.254: v1(23.71,61.96) 24.24,62.49 25.61,62.49 v1(30.13,67.01)
+RTC_CELL_VBAT: length 16.2
  TOP w0.127: v2(28.78,64.05) 29.21,64.05 RE6.2
  TOP w0.203: UE1.122 34.57,71.81 34.24,72.14 v1(33.13,72.14) 32.3,72.14 CE12.1
  TOP w0.508: v1(30.77,64.19) 30.77,64.51 30.39,64.89 RE6.2
  IN2 w0.508: v1(30.77,64.19) 31.68,64.19 32.55,65.06 32.55,71.64 32.56,71.65 32.56,71.72 32.99,72.14 v1(33.13,72.14)
+RTC_PWR: length 7.8
  TOP w0.508: D1.3 66.24,28.35 64.51,26.63 v2(62.34,26.63) 61.34,26.63 60.41,27.55 Q1.2
+RTC_SOC: length 74.4
  TOP w0.457: CC52.1 122.31,60.56 v1(122.31,60.9) 122.75,61.35 CC51.1
  TOP w0.508: 65.25,38.6 v3(66.92,38.6) 67.38,38.6 68.25,39.47 74.62,39.47 78.13,42.98 v1(78.14,42.98) ; RC77.1 103.92,57.4 v1(104.24,57.08) 104.56,57.4 RC82.1
  IN1 w0.508: v1(78.14,42.98) 78.57,43.42 80.67,43.42 81.23,43.98 92.52,43.98 93.74,45.2 93.76,45.2 94.32,45.77 94.32,46.66 97.82,50.16 97.82,50.48 98.48,51.14 99.01,51.14 104.24,56.36 v1(104.24,57.08) 105.63,57.08 107.86,59.3 v1(107.86,60) 108.54,60.69 111.46,60.69 113.09,62.32 116.09,62.32 116.44,61.96 121.18,61.96 122.23,60.9 v1(122.31,60.9)
  BOTTOM w0.254: v1(122.31,60.9) 122.31,60.88 122.29,60.86 122.29,60.39 122.77,59.92 UC1.BR23
  BOTTOM w0.508: v1(107.86,60) 108.49,60 RC87.1
+RTC_VCC: length 150.9
  TOP w0.127: v1(203.36,34.35) v3(204.02,34.35)
  TOP w0.508: v1(66.33,26.22) 67.73,27.62 R1.2
  IN2 w0.508: v1(66.33,26.22) 66.95,26.84 67.67,26.84 68.42,26.09 99.97,26.09 101.25,27.37 122.6,27.37 123.48,28.25 128,28.25 129.09,29.35 133.34,29.35 136.44,32.45 144.83,32.45 147.97,29.31 149.18,29.31 150.56,27.93 159.05,27.93 159.5,28.38 165.39,28.38 166.95,29.94 171.57,29.94 172.58,28.94 175.99,28.94 180.04,32.98 188.88,32.98 189.44,33.54 197.92,33.54 198.8,34.43 203.28,34.43 v1(203.36,34.35)
  BOTTOM w0.508: v1(203.36,34.35) 203.36,36.64 JIOB1.11
+SPLL_PVDD: length 5.2
  TOP w0.102: LV7.2 131.25,122.12 v2(132.08,121.29)
  TOP w0.508: v1(130.91,125.37) 131.07,125.21 CV85.1 131.11,123.85 CV84.1 131.11,122.13 LV7.2
  BOTTOM w0.381: UV1.H7 130.54,125.74 v1(130.91,125.37)
+SPLL_VDDC: length 3.7
  TOP w0.102: 133.18,120.03 LV8.2
  TOP w0.112: v3(133.18,119.29) 133.18,120.03
  TOP w0.508: v1(130.93,126.24) 131.8,125.38 131.8,124.71
  BOTTOM w0.305: UV1.H8 130.89,126.24 v1(130.93,126.24)
+TP_VDD: length 50.3
  TOP w0.508: v1(116.62,28.86) 115.65,28.86 115.29,28.5 R45.1 115.27,28.05 115.27,27.31 ; 115.27,27.31 123.06,27.31 123.34,27.59 R43.1 R34.1 R35.1 125.39,27.41 129.52,27.41 130.17,28.07 Q8.2 R42.1 ; 115.27,27.31 v3(111.88,27.31) 106.76,27.31 104.63,29.45 v1(104.63,31.68)
  BOTTOM w0.508: Q5.1 110.71,27.74 111.04,28.08 C26.1 112.82,28.08 113.66,28.91 116.57,28.91 v1(116.62,28.86) 116.65,28.83 116.65,28.48 116.95,28.18 117.69,28.18 118.05,28.54 JTP1.8 118.05,31.57 117.94,31.68 R46.1 ; R39.1 v1(104.63,31.68)
+TS_VDD:
  vias: v1(216.11,38.41) v1(216.06,37.78) v1(216.58,38.04) v3(215.39,38.55)
+TS_VDD_IN: length 1
  TOP w0.112: 215.22,34.46 v3(216.21,34.46)
+TSVDD: length 7.8
  TOP w0.356: 117.29,132.6 CV20.1 117.6,133.42 v1(117.62,133.45)
  TOP w0.508: LV2.2 112.98,133.15 v3(113.53,132.6) 117.29,132.6
  BOTTOM w0.381: UV1.AD17 117.62,133.88 v1(117.62,133.45)
+USB2_VCC:
  vias: v1(198.79,35.81) v1(199.42,35.81) v1(200.06,35.81) v1(200.69,35.81) v1(201.33,35.81) v3(201.88,34.62)
+USB3_VCC:
  vias: v1(17.43,52.57) v1(17.43,51.94) v1(18.07,52.57) v1(18.07,51.94) v3(19.5,37.64)
+V_DDR_REFA: length 3.2
  TOP w0.112: RD10.2 v3(71.7,68.75)
  BOTTOM w0.305: JDIMM1.164 71.82,67.24 72.17,66.89 v1(72.75,66.89)
+V_DDR_REFA_R: length 109.1
  TOP w0.508: v1(79.41,111.95) 81.82,109.53 99.98,109.53 v3(102.09,107.42) v1(107.48,102.04) ; CD27.1 RD11.1 70.14,64.62 69.87,64.35 69.13,64.35 68.79,64.01 68.79,63.99 68.61,63.81 v1(68.61,63.77)
  IN1 w0.508: v1(79.41,111.95) 79.03,112.32 73.05,112.32 70.39,109.66 70.39,64.96 69.88,64.45 69.12,64.45 68.61,63.94 v1(68.61,63.77)
  BOTTOM w0.203: UC1.F36 114.51,89.88 114.24,89.88 114.09,90.04 113.66,90.04 112.72,90.98 112.72,93.36
  BOTTOM w0.508: 112.72,93.36 111.56,94.52 110.87,94.52 107.48,97.91 v1(107.48,102.04)
+V_DDR_REFB: length 3.2
  TOP w0.112: v2(58.71,70.75) 59.04,70.42 CD51.1
  BOTTOM w0.305: JDIMM2.164 59.69,67.24 60.05,66.89 v1(60.05,66.8)
+V_DDR_REFB_R: length 119.6
  TOP w0.508: v1(108.24,101.82) 108.24,102.14 100.05,110.33 82.04,110.33 v3(81.54,110.83) v1(80.43,111.95) ; RD22.1 CD52.1 57.87,65.84 57.06,65.84 v1(56.99,65.78)
  IN1 w0.508: v1(80.43,111.95) 79.44,112.93 72.8,112.93 69.58,109.71 61.14,109.71 v1(60.61,110.23)
  IN2 w0.508: v1(56.99,65.78) 57.6,66.39 57.6,78.76 55.03,81.34 55.03,102.87 57.82,105.66 57.82,108.64 59.41,110.23 v1(60.61,110.23)
  BOTTOM w0.203: 113.18,94 113.18,91 113.79,90.39 114.22,90.39 UC1.E36
  BOTTOM w0.508: v1(108.24,101.82) 108.24,98.23 111.22,95.25 111.92,95.25 113.18,94
+VGA_CORE: length 2.8
  TOP w0.508: v1(127.41,128.4) 127.22,128.4 126.75,127.94 CV106.1 ; RV42.2 120.17,137.36 v1(120.85,137.36)
  BOTTOM w0.508: v1(125.76,129.48) 126.14,129.86 UV1.N12
  vias: v1(104.76,137.83) v1(104.76,137.24) v1(105.06,122.46) v1(105.06,121.85) v1(105.06,121.27) v1(105.06,120.68) v1(105.19,124.9) v1(105.19,124.29) v1(105.19,123.68) v1(105.19,123.07) v1(105.34,137.83) v1(105.34,137.24) v1(105.34,136.62) v1(105.65,122.46) v1(105.65,121.85) v1(105.65,121.27) v1(105.65,120.68) v1(105.77,125.51) v1(105.77,124.9) v1(105.77,124.29) v1(105.77,123.68) v1(105.77,123.07) v1(105.93,137.83) v1(105.93,137.24) v1(105.93,136.62) v1(105.93,136.04) v1(106.23,122.46) v1(106.23,121.85) v1(106.23,121.27) v1(106.23,120.68) v1(106.36,125.51) v1(106.36,124.9) v1(106.36,124.29) v1(106.36,123.68) v1(106.36,123.07) v1(106.51,137.83) v1(106.51,137.24) v1(106.51,136.62) v1(106.51,136.04) v1(106.51,135.42) v1(106.82,122.46) v1(106.82,121.85) v1(106.82,121.27) v1(106.82,120.68) v1(106.94,124.9) v1(106.94,124.29) v1(106.94,123.68) v1(106.94,123.07) v1(107.1,137.83) v1(107.1,137.24) v1(107.1,136.62) v1(107.1,136.04) v1(107.1,135.42) v1(107.1,134.83) v1(107.7,137.83) v1(107.68,137.23) v1(107.68,136.62) v1(107.68,136.04) v1(107.68,135.43) v1(107.68,134.81) v1(107.68,134.17) v1(115.73,124.58) v1(116.56,124.58) v1(117.26,123.82) v1(119.79,130.41) v1(119.82,129.5) v1(120.82,132.4) v1(120.86,136.32) v1(121.77,135.3) v1(122.77,134.3) v1(122.84,130.61) v1(123.74,131.53) v1(124.61,134.19) v1(124.67,136.41) v1(125.65,131.38) v1(126.48,134.29) v1(126.71,135.24) v1(127.72,132.47) v3(116.25,123.36)
+VGA_CORE_TOPAZ: length 1.5
  TOP w0.102: RV24.2 v3(119.8,122.19)
  vias: v1(118.11,128.61) v1(118.29,131.02) v1(118.7,132.22) v1(120.46,123.82) v1(121.3,127.57) v1(121.3,126.85) v1(121.32,124.58) v1(121.43,123.82) v1(122.69,127.74)
A4WP_PRESENT: length 3.2
  TOP w0.112: v1(127.1,52.84) 127.07,52.87 RC61.2 126.49,52.14 125.79,51.44 v2(125.71,51.44)
  BOTTOM w0.102: UC1.CF17 126.75,53.19 v1(127.1,52.84)
AC_DIS: length 224.7
  TOP w0.112: PQB31.2 198.03,47.64 PRB45.1 198.03,48.19 v2(197.44,48.78) v1(197.44,49.74) ; UE1.69 48.15,82.69 v1(47.66,82.2)
  IN2 w0.124: v1(47.66,82.2) 47.66,86.48 48.93,87.75 48.93,89.91 49.31,90.29 49.31,92.64 51.66,94.99 51.66,107.88 56.99,113.22 85.26,113.22 87.28,111.2 113.52,111.2 113.95,111.63 122.78,111.63 126.64,107.77 129.91,107.77 130.96,108.82 134.98,108.82 139.14,104.66 143.44,104.66 144.08,105.3 157.29,105.3 168.02,94.58 168.02,88.86 168.52,88.35 168.52,76.23 172.97,71.79 180.51,71.79 181.47,70.83 181.47,67.48 184.81,64.14 184.81,62.06 v1(185.44,61.43)
  IN3 w0.135: v1(185.44,61.43) 185.44,60.49 188.1,57.83 188.1,53.96 190.48,51.57 195.08,51.57 196.91,49.74 v1(197.44,49.74)
AC_PRESENT: length 6.4
  BOTTOM w0.076: UC1.BU35 114.9,58.69 114.45,58.69 114.22,58.72 114.07,58.8 113.77,58.8 113.66,58.77 113.6,58.71 113.52,58.65 113.48,58.61 RC66.2 111.3,59.05 109.9,59.05 RC97.2
ACIN_CHG: length 5.5
  TOP w0.112: PRB09.2 202.29,48.52 v2(201.91,48.9)
  TOP w0.254: PQB31.1 201.33,47.3 v1(201.77,47.3) 202.03,47.05 PCB02.1 ; PRB10.1 PCB02.1 ; PCB02.1 202.4,47.84 PRB09.2
  BOTTOM w0.203: v1(201.77,47.3) 202.15,46.92 PUB01.16
ACLIN_CHG: length 2.9
  BOTTOM w0.203: PRB16.1 PRB18.1 204.89,49.18 204.43,48.72 PUB01.20
ACOK_CHG: length 2.5
  TOP w0.254: v1(206.75,48.1) 206.75,48.65 206.5,48.9 PRB22.1
  BOTTOM w0.203: PUB01.24 206.03,47.88 206.23,48.08 206.73,48.08 v1(206.75,48.1)
ADDR_VBOOT_CPU: length 3.2
  TOP w0.112: v1(171.11,57.36) 171.1,57.36 170.59,57.88 v2(170.59,58.17)
  TOP w0.254: v1(171.11,57.36) 171.12,57.36 PRZ69.1
  BOTTOM w0.203: PUZ01.21 171.58,56.9 v1(171.11,57.36)
ADJ_2.5V: length 6.1
  TOP w0.254: PR2503.1 64.95,109.82 64.2,109.82 v2(63.85,110.17) PR2502.2 PC2505.2 64.93,111.69 PU2501.7
ALERT#: length 3.1
  BOTTOM w0.112: v2(175.99,67.66) R54.2 175.99,66.1 U3.6
ALERT#_CPU: length 2.3
  BOTTOM w0.112: PUZ01.33 176.43,59.7 176.71,59.98 PRZ47.1
ALL_SYS_PWRGD: length 141.8
  TOP w0.112: v1(54.76,75.24) 54.75,75.23 54.35,75.23 RE41.1 ; RC148.1 RC147.2 94.27,45.23 RC146.2 ; RC148.1 93.8,43.51 CC78.2 92.85,43.44 CC69.1 ; RC148.1 94.24,44.13 94.35,44.02 v1(94.35,43.9) 94.5,43.75 UC8.2 ; UC6.4 98.6,41.35 99.12,41.87 v2(99.12,42.25) 99.12,44.1 v1(99.07,44.16)
  IN2 w0.124: v1(94.35,43.9) 94.23,43.9 93.18,42.85 90.54,42.85 89.88,42.18 82.13,42.18 81.46,41.51 80.38,41.51 77.95,39.07 76.79,39.07 76.19,39.68 61.52,39.68 59.02,42.18 56.83,42.18 55.42,43.59 55.42,46.71 53.3,48.83 53.3,56.84 51.72,58.42 51.72,65.51 49.82,67.42 49.82,75.81 47.09,78.54 47.09,86.23 48.68,87.82 v1(48.68,90.48)
  IN3 w0.135: v1(53.24,97.43) 53.37,97.43 55.79,95.01 55.79,84.54 54.2,82.95 54.2,75.38 54.34,75.24 v1(54.76,75.24) ; v1(94.35,43.9) 94.43,43.98 98.88,43.98 v1(99.07,44.16)
  BOTTOM w0.119: v1(48.68,90.48) 49.06,90.48 53.24,94.67 v1(53.24,97.43)
ALWON: length 32.1
  TOP w0.112: v1(19.24,84.77) 18.89,84.77 v2(18.47,84.35) ; v1(36.99,71.86) 36.99,71.95 36.73,72.21 UE1.121
  IN3 w0.135: v1(36.99,71.86) 36.99,71.95 36.58,72.35 35.72,72.35 32.94,75.13 23.89,75.13 19.34,79.69 19.34,84.67 v1(19.24,84.77)
  BOTTOM w0.254: PR506.1 20.15,86.77 19.21,85.83 19.21,84.79 v1(19.24,84.77)
AMBER_LED_BAT: length 2.9
  BOTTOM w0.112: v2(16.87,128.05) R28.2 Q2.1
ASGATE_CHG: length 28
  TOP w0.127: v1(193.96,57.02) 194.43,56.55 v2(194.43,56.27)
  TOP w0.508: PRB07.2 v1(193.96,57.02)
  IN2 w0.508: v1(203.36,42.6) 203.35,42.59 199.12,42.59 197.46,44.25 194.72,44.25 191.3,47.68 191.3,55.24 192.25,56.19 193.58,56.19 193.96,56.57 v1(193.96,57.02)
  BOTTOM w0.203: PUB01.7 203.63,42.87 v1(203.36,42.6)
AUD_AGND: length 26.9
  TOP w0.127: v3(20.98,9.32) 20.87,9.22 RA16.1 ; v1(17.18,13.52) v3(16.07,13.52)
  TOP w0.203: UA1.19 30.26,16.25 v1(30.07,16.44)
  TOP w0.356: v1(17,14.73) 16.67,15.06 RA35.2
  TOP w0.508: RA16.1 v1(19.59,9.84) ; v1(31.66,19.29) 31.66,18.82 CA23.2 32.68,18.63 CA24.2 ; RA18.1 v1(24.04,19.36)
  GND1 w0.254: 10,7.23 JHP1.7 ; JHP1.7 11.08,7.23 ; JHP1.7 11.08,7.9 ; JHP1.7 8.92,7.9 ; JHP1.7 8.92,7.23
  VCC w0.203: JHP1.7 11.08,7.9 ; JHP1.7 8.92,7.23 ; JHP1.7 8.92,7.9 ; JHP1.7 11.08,7.23 ; JHP1.7 10,7.23
  GND2 w0.254: 8.92,7.23 JHP1.7 ; JHP1.7 11.08,7.23 ; JHP1.7 10,7.23 ; JHP1.7 11.08,7.9 ; JHP1.7 8.92,7.9
  BOTTOM w0.508: CA36.2 RA34.2 v1(17.18,13.52) ; v1(18.88,9.38) RA33.2 CA35.2
  vias: v1(21.05,16.63) v1(21.05,16) v1(25.18,19.3) v1(25.37,18.47) v1(25.82,19.3) v1(26,18.47) v1(27.03,8.75) v1(29.35,9.94) v3(25.19,17.83)
AUD_HP1_JACK_L: length 5.4
  TOP w0.203: UA1.25 28.63,13.21 28.58,13.26 27.31,13.26 27.07,13.5 v2(25.89,13.5) 25.48,13.5 24.95,14.03 RA27.1
  TOP w0.254: RA28.2 RA27.1
AUD_HP1_JACK_L1: length 4.2
  TOP w0.127: RA27.2 23.5,14.49 v2(23.5,15.83)
  TOP w0.254: LA2.1 22.72,12.92 RA29.2 22.97,14.03 RA27.2
AUD_HP1_JACK_R: length 5.2
  TOP w0.203: UA1.26 28.31,12.81 28.2,12.93 v2(27.05,12.93) 25.86,12.93 25.37,12.44 RA30.1
  TOP w0.254: RA31.2 RA30.1
AUD_HP1_JACK_R1: length 3.4
  TOP w0.127: v2(22.68,10.07) LA3.1
  TOP w0.305: RA30.2 23.16,12.44 RA32.2 22.72,11.14 LA3.1
AUD_PC_BEEP: length 1.7
  TOP w0.203: CA32.2 33.74,16.21 33.46,15.93 UA1.11
AUD_PC_BEEP_C: length 16.7
  TOP w0.112: DA3.1 23.43,24.6 v2(24.28,25.45)
  TOP w0.254: DA3.1 23.62,23.81 23.87,23.55 23.87,23.01 v1(23.28,22.41) ; RA23.1 34.91,20.38 v1(33.12,20.38)
  IN1 w0.254: v1(23.28,22.41) 23.78,22.41 25.31,20.89 32.61,20.89 v1(33.12,20.38)
AUD_SENSE_A: length 4.6
  TOP w0.203: RA14.2 CA24.1 33.83,18.05 RA15.1 33.62,17.97 33.26,17.6 33.26,16.24 33.06,16.04 UA1.12
AUD_SPK_L+: length 0.6
  TOP w0.127: v1(29.32,5.65) 29.78,5.65 v2(29.87,5.56)
  vias: v1(28.74,5.65) v1(31.17,9.08) v1(31.17,8.49)
AUD_SPK_L+_C:
  vias: v1(14.38,4.69) v1(14.38,4.06) v2(19.27,6.38)
AUD_SPK_L-: length 0.7
  TOP w0.127: v1(29.32,4.38) v2(29.32,3.72)
  vias: v1(28.74,4.38) v1(31.83,9.08) v1(31.94,8.49)
AUD_SPK_L-_C:
  vias: v1(14.38,3.3) v1(14.38,2.66) v2(14.91,2.92)
AUD_SPK_R+: length 0.7
  TOP w0.127: v2(24.89,1.56) 24.8,1.65 v1(24.24,1.65)
  vias: v1(23.66,1.65) v1(33.05,9.28) v1(33.33,8.76)
AUD_SPK_R+_C: length 3.1
  TOP w0.127: v2(16.33,1.49) 18.71,1.49 DA2.2
  vias: v1(18.88,2.88) v1(19.49,2.88)
AUD_SPK_R-: length 0.9
  TOP w0.127: v1(26.4,2.73) v2(27.26,2.73)
  vias: v1(25.81,2.73) v1(32.47,9.08) v1(32.7,8.54)
AUD_SPK_R-_C:
  vias: v1(18.14,3.61) v1(18.18,4.29) v2(24.62,3.78)
AUD_VREF: length 2.6
  TOP w0.203: CA16.1 26.97,14.58 v2(27.63,14.58) 28.44,14.58 28.61,14.41 UA1.22
AUX_ON: length 39.3
  TOP w0.112: v1(37.95,69.91) 38.25,69.6 38.25,67.88 UE1.3 ; v2(14.63,88.15) 15.43,88.15 RL11.2 16.63,88.56 UL2.4 16.89,87.71 v1(16.62,87.43)
  IN3 w0.135: v1(37.95,69.91) 37.68,69.91 37.55,70.04 37.55,71.86 36.82,72.58 35.82,72.58 33.03,75.37 24.05,75.37 19.66,79.76 19.66,83.84 19.87,84.05 19.87,84.7 19.07,85.5 18.24,85.5 16.62,87.13 v1(16.62,87.43)
BA_PWR: length 42.2
  TOP w0.112: v2(198.59,51.52) 199.19,51.52 v1(199.55,51.16)
  TOP w0.508: PDB01.3 200.35,50.37 v1(199.55,51.16) ; PRB41.2 175.23,35.93 PQB28.1 174.73,34.98 175.87,33.84 177.07,33.84 v1(177.2,33.71)
  IN1 w0.508: v1(199.55,51.16) 186.54,51.16 177.58,42.2 177.58,35.24 177.2,34.86 v1(177.2,33.71)
BAT1_LED#: length 62.8
  TOP w0.112: v2(30.02,87.78) 29.51,87.27 RE21.1 30.32,85.89 32.34,85.89 v1(32.52,85.71) ; v1(34.47,78.22) 34.48,78.21 UE1.106
  IN1 w0.119: v1(29.52,129.25) 29.52,128.72 30.13,128.1 32.2,126.03 32.2,114.27 33.24,113.23 33.24,89.27 32.36,88.39 32.36,85.87 v1(32.52,85.71) 33.02,85.21 33.63,85.21 34.66,84.17 34.66,78.42 v1(34.47,78.22)
  BOTTOM w0.112: Q15.1 28.96,130.85 29.52,130.3 v1(29.52,129.25)
BAT2_LED#: length 107.5
  TOP w0.112: v1(35.39,64.44) 35.51,64.32 37.47,64.32 RE23.1 37.12,65.08 37.12,66.12 37.35,66.35 UE1.1
  IN1 w0.119: v1(35.39,64.44) 35.75,64.44 38.82,61.37 43.1,61.37 43.53,60.94 49.24,60.94 49.74,61.43 49.74,72.66 48.39,74.01 48.39,78.75 48.97,79.34 48.97,81.75 46.59,84.13 45.26,84.13 43.2,86.2 38.55,86.2 36.58,88.17 36.58,90.01 36.03,90.55 36.03,99.6 37.06,100.63 37.06,115.05 32.42,119.69 32.42,126.8 30.01,129.22 30.01,130.11 30.88,130.98 v1(30.88,132.15)
  BOTTOM w0.112: Q15.4 v1(30.88,132.15) 31.3,132.15 v2(31.49,132.34)
BATGONE_CHG: length 6
  BOTTOM w0.112: v2(210.46,49.23) 209.74,49.23 PRB24.1
  BOTTOM w0.203: PRB24.1 PRB23.1 PCB09.1 207.81,48.61 207.23,48.04 207.23,47.19 206.97,46.92 PUB01.25
BATT_WHITE_LED_R#: length 10.7
  TOP w0.112: v1(24.55,130.87) v2(23.92,130.87)
  IN3 w0.135: v1(24.55,130.87) 25.43,131.76 28.71,131.76 v1(29.1,132.15)
  BOTTOM w0.112: Q15.3 v1(29.1,132.15) ; Q4.2 21.8,131.83 22.77,130.87 Q3.1 v1(24.55,130.87)
BEEP: length 91.5
  TOP w0.112: v1(44.79,75.24) 44.98,75.05 48.93,75.05 49.57,74.41 50.22,74.41 50.42,74.21 UE1.45 ; v1(36.84,53.99) v2(36.84,53.34) ; DA3.3 v1(19.85,22.84)
  IN1 w0.119: v1(44.79,75.24) 44.1,75.24 43.34,76 42.13,76 41.56,76.58 40.36,76.58 39.22,75.43 38.26,75.43 38,75.7 32.03,75.7 30.95,74.62 30.95,73.2 30.84,73.08 30.29,73.08 29.07,71.86 29.07,67.22 34.32,61.97 34.32,57.72 36.84,55.2 v1(36.84,53.99)
  IN3 w0.135: v1(19.85,22.84) 17.69,25 17.69,29.41 28.16,39.89 30.95,39.89 v1(31.95,40.89)
  BOTTOM w0.112: v1(36.84,53.99) 36.15,53.99 31.95,49.79 v1(31.95,40.89)
BGATE_CHG: length 33.3
  TOP w0.112: v1(207.23,43.68) v2(207.76,43.68)
  IN3 w0.508: v1(207.23,43.68) 206.92,44 206.92,45.78 204.63,48.06 201.12,48.06 200.51,47.46 197.69,47.46 197.18,47.96 185.86,47.96 v1(182.71,51.11)
  BOTTOM w0.203: v1(207.23,43.68) 207.23,43.87 206.98,44.12 PUB01.32
  BOTTOM w0.508: PCB28.1 180.93,50.35 PQB13.4 182.46,50.35 182.71,50.6 v1(182.71,51.11)
BKLT_CTRL: length 6.7
  TOP w0.112: R11.1 R75.2 ; R75.2 218.55,50.71 218.17,50.32 218.17,50.17 v2(217.65,49.65) 216.84,48.84 R79.2 ; R75.2 218.55,53.03 218.44,53.14 D2.1
BKLT_IN_EC: length 160.1
  TOP w0.102: v2(129.71,52.05) 129.71,50.91 130.14,50.49 v1(130.14,50.45)
  TOP w0.112: RC13.2 130.79,50.45 v1(130.14,50.45) ; v1(42.21,77.78) 44.48,77.78 46.16,79.46 46.41,79.46 47.02,80.06 47.7,80.06 48.95,81.31 UE1.67
  IN2 w0.124: v1(42.21,77.78) 42.21,76.04 42.77,75.48 42.77,67.21 43.26,66.72 43.26,65.67 43.45,65.48 43.45,63.35 47.64,59.16 47.64,56.16 49.18,54.62 49.18,46.39 48.56,45.77 48.56,41.6 52.61,37.54 57.36,37.54 60.51,34.39 67.48,34.39 67.79,34.08 80.76,34.08 81.19,34.5 117.61,34.5 119.47,36.35 119.98,36.35 120.38,35.95 130.58,35.95 132.11,37.49 v1(134.07,37.49)
  IN3 w0.135: v1(134.07,37.49) 133.59,37.97 133.59,41.47 135.14,43.02 135.14,44.1 133.64,45.61 133.64,49.03 133.5,49.16 131.43,49.16 v1(130.14,50.45)
  BOTTOM w0.102: UC1.CK11 130.21,50.47 130.21,50.45 v1(130.14,50.45)
BLON_OUT_C: length 3.9
  TOP w0.112: v1(213.89,47.22) v2(214.25,46.86) 214.5,46.86 214.56,46.92 R76.2 R78.1
  BOTTOM w0.112: v1(213.89,47.22) 213.68,47.22 213.41,46.95 JEDP1.28
BLUETOOTH_EN: length 204.2
  TOP w0.112: v1(58.45,129.48) 60.49,129.48 v2(62.24,131.22) 64.68,133.66 DW1.1
  IN2 w0.124: v1(58.45,129.48) 58.45,127.95 56.93,126.42 54.96,126.42 53.91,125.37 52.74,125.37 42.56,115.19 42.56,113.48 41.29,112.21 41.29,103.65 46.31,98.63 46.31,93.83 44.93,92.45 44.93,87.78 45.17,87.54 45.17,81.68 44.35,80.85 44.35,79.44 44.67,79.12 44.67,77.78 43.98,77.09 43.98,73.14 45.02,72.1 45.02,67.91 49.19,63.74 49.19,62.59 49.71,62.07 49.71,57.16 51.29,55.58 51.29,47.75 52.24,46.8 52.24,42.23 52.94,41.54 54.62,41.54 56,40.17 58.13,40.17 61.54,36.76 68.46,36.76 68.65,36.57 78.42,36.57 81.3,39.46 84.65,39.46 85.13,38.98 94.65,38.98 94.8,38.84 96.94,38.84 99.33,41.23 108.03,41.23 111.31,44.51 113.75,44.51 114.23,44.03 114.95,44.03 117.24,41.74 117.76,41.74 118.33,42.31 118.33,44.02 119.37,45.06 127.21,45.06 128.66,46.51 v1(129.05,46.51)
  BOTTOM w0.076: RC174.2 129.34,45.19 129.34,46.18 129.05,46.48 v1(129.05,46.51) 128.56,47 128.56,47.74 128.66,47.84 128.66,48.22 128.4,48.47 UC1.CP14
BLUETOOTH_EN_R: length 5.9
  TOP w0.112: v1(68.74,134.35) 68.06,133.66 DW1.2 v2(66.59,132.44)
  BOTTOM w0.112: v1(68.74,134.35) 69.19,133.9 JWLAN1.54
BOARD_ID: length 21
  TOP w0.112: v2(36.56,93.09) RE1.2 35.8,91.24 RE2.2 35.8,90.19 CE11.1 35.66,90.05 35.66,89.57 v1(35.53,89.44) ; v1(37.58,76.58) 37.21,76.21 UE1.111
  IN2 w0.124: v1(35.53,89.44) 36.48,88.48 36.48,87.69 37.94,86.23 37.94,83.94 38.82,83.07 38.82,78.09 38.39,77.66 38.07,77.66 37.58,77.16 v1(37.58,76.58)
BOARD_ID1: length 4.5
  TOP w0.102: 130.59,49.54 RC72.1
  TOP w0.112: v1(129.04,52.32) 129.43,51.93 129.43,51.77 129.5,51.69 129.5,50.69 v2(129.56,50.63) 129.56,49.93 RC72.1 ; RC70.2 130.59,49.54
  BOTTOM w0.089: v1(129.04,52.32) 129.04,52.32 129.59,52.52 UC1.CG12
BOARD_ID2: length 3.9
  TOP w0.102: v1(127.92,50.23) 127.92,50.21 127.78,50.07 v2(127.78,49.25) 127.78,48.15 RC71.1 127.16,47.35 RC69.2
  BOTTOM w0.076: UC1.CM14 128.04,50.21 127.94,50.21 v1(127.92,50.23)
BOOT1_CHG:
  vias: v2(201.42,45.33)
BP_0: length 3.9
  BOTTOM w0.102: UV1.U1 122.93,122.19
  BOTTOM w0.112: RV82.1 121.38,119.58 v2(122.35,120.54) 122.35,121.61 122.93,122.19
BP_1: length 5.3
  BOTTOM w0.102: 122.39,122.19 123.34,123.14 UV1.U3
  BOTTOM w0.112: RV81.1 120.62,119.9 120.84,120.11 121.29,120.11 121.64,120.45 121.64,121.44 v1(121.9,121.7) 122.39,122.19
BST1_VGA: length 2
  TOP w0.112: v2(79.73,126.02) 79.37,126.02 78.39,127 PRV21.1
BST2_VGA: length 1.3
  TOP w0.112: v2(76.01,134.12) 76.34,133.79 PRV01.1
BST_1.2V_R: length 4.2
  TOP w0.112: PRM02.2 41.32,30.41 v2(42.43,30.41)
  TOP w0.508: PCM12.1 41.25,27.9 PRM02.2
BST_1.05V:
  vias: v1(162.4,42.86)
BST_1.05V_R: length 3.1
  BOTTOM w0.112: PCH12.1 160.6,41.42 159.5,41.42 v2(159.25,41.66)
  BOTTOM w0.508: PCH12.1 PRH06.2
BST_3V: length 2
  BOTTOM w0.112: v2(22.34,38.62) 22.16,38.62 20.98,39.8 PR301.1
BST_3V_R: length 1.1
  BOTTOM w0.112: PC307.1 v2(24.41,40.42)
BST_5V:
  vias: v1(24.05,99.41)
BST_5V_R:
  vias: v1(22.97,101.98)
BST_+1.35VGPU: length 3.3
  TOP w0.112: PRW06.1 v2(143.71,108.13)
  TOP w0.508: v1(145.53,109.12) 145.32,109.12 144.81,108.61 PRW06.1
  BOTTOM w0.254: PUW01.1 v1(145.53,109.12)
BST_+1.35VGPU_R: length 0.9
  TOP w0.112: 146.33,108.38 v2(146.33,109.3)
BST_VCCSA: length 0.8
  TOP w0.112: 168.25,54.45 168.25,53.78 v2(168.16,53.69)
  vias: v1(168.94,54.35)
BST_VCCSA_R: length 1.4
  TOP w0.112: PRA01.2 166.87,56.22 v2(167.01,56.36)
BST_VCORE1: length 1.2
  BOTTOM w0.127: PRI01.1 v2(162.82,67.94)
BST_VCORE1_R: length 2.6
  BOTTOM w0.112: PRI01.2 v2(163.99,70.65)
  BOTTOM w0.635: PRI01.2 PCI09.1
BST_VCORE2:
  vias: v1(167.6,85.71)
BST_VCORE2_R: length 1.3
  BOTTOM w0.112: v2(170.38,83.82) 170.38,84.16 PCI29.1
CAM_DET#: length 126.7
  TOP w0.112: v1(174.41,39.3) v2(174.41,38.55) ; RC204.2 209.2,54.96 R96.2 209.48,54.91 209.97,54.43 v1(210.11,54.43)
  IN1 w0.119: v1(124.11,41.66) 123.63,42.15 123.63,43.7 123.89,43.97 124.4,43.97 125.76,45.33 125.76,48.32 125,49.08 v1(125,50.35)
  IN2 w0.124: v1(124.11,41.66) 124.47,41.31 126.06,41.31 126.87,42.12 127.32,42.12 127.45,42 128.7,42 128.97,42.27 128.97,43.4 129.35,43.77 131.19,43.77 131.94,44.53 133,44.53 133.49,45.02 134.8,45.02 135.99,43.82 140.17,43.82 144.66,39.33 147.07,39.33 147.5,38.91 152.64,38.91 153.49,38.05 158.66,38.05 160.47,39.86 166.23,39.86 167.03,39.06 174.16,39.06 v1(174.41,39.3)
  IN3 w0.135: v1(174.41,39.3) 177.33,39.3 179.29,37.34 190.41,37.34 190.86,36.9 194.48,36.9 196.84,39.26 197.35,39.26 197.92,39.83 197.92,40.8 198.82,41.7 205.54,41.7 206.06,42.21 208.79,42.21 209.36,41.63 211.07,41.63 212.17,42.73 212.17,45.52 212.22,45.58 212.22,46.18 212.4,46.35 212.4,51.27 210.35,53.32 210.35,54.19 v1(210.11,54.43)
  BOTTOM w0.076: v1(125,50.35) 124.88,50.35 124.75,50.22 123.56,50.22 UC1.CM22
CAM_DET#_R: length 7.1
  TOP w0.112: R96.1 210.41,54.96 v1(210.61,54.76) 210.61,54.17 v2(210.41,53.97)
  BOTTOM w0.112: v1(210.61,54.76) 211.01,55.15 211.51,55.15 211.65,55.29 211.65,57.75 211.65,57.76 211.65,58.81 211.79,58.95 JEDP1.4
CAM_EN#: length 1.1
  TOP w0.112: TP6.1 130.36,54.03 v1(130.84,54.03)
  BOTTOM w0.112: UC1.CE9 130.89,54.03 v1(130.84,54.03)
CAP_LED: length 31.6
  TOP w0.112: v1(56.37,35.14) 56.39,35.14 57.2,35.95 R48.2 ; v1(79.41,31.05) v2(79.96,31.05)
  IN2 w0.124: v1(56.37,35.14) 56.37,34.73 60.57,30.52 61.04,30.52 61.65,29.91 65.07,29.91 65.68,30.52 69.74,30.52 70.28,31.07 76.56,31.07 76.99,31.49 78.96,31.49 v1(79.41,31.05)
  BOTTOM w0.112: JKB1.27 80.55,32.19 v1(79.41,31.05)
CAP_LED#: length 66.5
  TOP w0.112: R47.2 50.33,34.15 v2(50.12,34.35) ; UE1.93 38.55,82.13 40.29,80.39 v1(40.29,80.3)
  TOP w0.254: R47.2 51.74,34.15 52.24,33.64 Q9.3 53.17,33.64 53.82,34.29 53.82,35.05 54.26,35.49 55.84,35.49 v1(55.87,35.47)
  IN2 w0.124: v1(55.87,35.47) 55.67,35.66 51.15,35.66 47.08,39.74 47.08,47.04 48.87,48.84 48.87,54.61 47.41,56.07 47.41,59.07 43.23,63.25 43.23,65.38 43.03,65.58 43.03,66.63 42.55,67.12 42.55,72.64 41.21,73.97 41.21,79.38 v1(40.29,80.3)
CAP_LED_Q: length 2.9
  TOP w0.112: v2(58.45,35.03) R48.1 Q12.1
CAP_LED_R#: length 6.4
  TOP w0.112: v2(56.35,29.17) Q12.2 56.35,34.11 55.85,34.6 Q9.1
CATERR#: length 5.4
  BOTTOM w0.076: UC1.AA4 134.85,80.98 135.75,80.98 136.06,81.29 137.37,81.29 138.21,80.45 RC3.2
CBN: length 4
  TOP w0.203: CA17.2 26.38,12.06 v2(28.02,12.06) 28.07,12.01 UA1.28
CBP: length 4.7
  TOP w0.203: v1(28.61,10.73) 28.61,10.98 28.84,11.21 UA1.30
  TOP w0.254: CA17.1 v1(25.5,10.45)
  IN1 w0.305: v1(25.5,10.45) 25.78,10.73 v1(28.61,10.73)
CFG0: length 7.6
  BOTTOM w0.076: 141.51,83.42 140.87,84.07 137.89,84.07 137.51,83.69 136.12,83.69 135.9,83.48 135.18,83.48 UC1.T4
  BOTTOM w0.112: 141.51,83.42 141.72,83.22 RC137.2
CFG1: length 4.7
  BOTTOM w0.076: 137.12,84.56 137.12,84.56 136.46,84.56 136.36,84.52 136.08,84.52 135.99,84.56 135.8,84.56 135.68,84.51 135.55,84.38 135.55,84.12 135.45,84.02 135.02,84.02 134.74,84.29 UC1.R4
  BOTTOM w0.102: TPC11.1 138.53,84.93 137.78,84.93 137.4,84.56 137.12,84.56
CFG2: length 6.6
  BOTTOM w0.076: 141.51,83.98 141.18,83.98 140.93,84.23 137.82,84.23 137.44,83.85 135.9,83.85 135.78,83.73 UC1.T3
  BOTTOM w0.112: 141.51,83.98 RC138.2
CFG3: length 9
  BOTTOM w0.076: UC1.R3 135.25,84.34 135.52,84.62 135.76,84.72 136.02,84.72 136.11,84.69 136.33,84.69 136.46,84.73 136.59,84.73 137,84.74 137.33,84.74 137.71,85.11 138.1,85.11 138.27,85.28 141.51,85.28 ; RC154.1 141.51,86.79
  BOTTOM w0.112: 141.51,85.28 141.84,85.28 TPC12.1 142,85.44 142,86.29 141.51,86.79
CFG4: length 6.3
  BOTTOM w0.076: UC1.J4 134.87,88.32 135.77,88.32
  BOTTOM w0.102: 138.91,90.99 138.84,90.99 136.59,88.74 136.19,88.74 135.77,88.32
  BOTTOM w0.112: 138.91,90.99 RC140.2
CFG5: length 7.3
  BOTTOM w0.076: RC142.2 141.14,87.49 140.19,87.49 139.69,86.99 137.9,86.99 136.99,86.07 135.89,86.07 135.73,85.91 135.42,85.91 135.26,86.06 UC1.M4
CFG6: length 7.3
  BOTTOM w0.076: UC1.J3 135.54,87.76 136.68,87.76 136.9,87.98 136.9,88.08
  BOTTOM w0.102: 139.42,89.71 138.53,89.71 136.9,88.08
  BOTTOM w0.112: RC141.2 140.61,89.23 140.13,89.71 139.42,89.71
CFG7: length 6.7
  BOTTOM w0.076: RC143.2 140.65,87.75 140.05,87.75 139.45,87.15 137.83,87.15 136.95,86.27 135.79,86.27 UC1.M3
CFG8: length 8.5
  BOTTOM w0.076: 141.51,84.68 140.45,84.68 140.16,84.39 137.75,84.39 137.37,84.02 136.18,84.02 UC1.R2
  BOTTOM w0.112: TPC13.1 142.76,86.03 142.5,85.77 142.5,85.04 142.13,84.68 141.51,84.68
CFG9: length 2.8
  BOTTOM w0.076: UC1.N2 136.16,85.87 137.02,85.87 137.69,86.54 137.7,86.54
  BOTTOM w0.102: 137.7,86.54 137.87,86.71 TPC14.1
CFG10: length 3.6
  BOTTOM w0.102: UC1.R1 136.63,84.37 137.48,84.37 137.7,84.59 139.52,84.59 TPC15.1
CFG11: length 4.4
  BOTTOM w0.102: 138.39,86.21 137.65,86.21 137.04,85.61 UC1.N1
  BOTTOM w0.112: 138.39,86.21 138.84,86.21 139.13,86.5 139.6,86.5 TPC16.1
CFG12: length 6.8
  BOTTOM w0.102: UC1.J2 136.36,88.51 136.69,88.51 138.67,90.5
  BOTTOM w0.112: TPC17.1 141.45,90.5 138.67,90.5
CFG13: length 5.4
  BOTTOM w0.076: UC1.L2 136.39,86.47 136.92,86.47 137.77,87.32 137.96,87.32 138.06,87.42 139.34,87.42 TPC18.1
CFG14: length 4.8
  BOTTOM w0.102: 139.21,90.01 138.5,90.01 UC1.J1
  BOTTOM w0.112: TPC19.1 140.49,90.01 139.21,90.01
CFG15: length 3
  BOTTOM w0.102: UC1.L1 136.93,86.74 137.69,87.5 137.89,87.5 138.06,87.67 139,87.67 TPC20.1
CFG16: length 5.3
  BOTTOM w0.076: UC1.L3 135.48,86.86 135.8,87 135.99,87 136.08,86.97 136.36,86.97 136.46,87 136.93,87 136.94,87.01
  BOTTOM w0.102: 136.94,87.01 137.63,87.71 137.83,87.71 138.97,88.84 138.97,88.9 TPC21.1
CFG17: length 4.7
  BOTTOM w0.076: UC1.L4 134.97,87.11 135.63,87.11 135.76,87.16 136.02,87.16 136.11,87.13 136.33,87.13 136.43,87.16 136.82,87.16 136.91,87.25
  BOTTOM w0.102: TPC23.1 138.27,88.41 137.76,87.9 137.55,87.9 136.91,87.25
CFG18: length 4.6
  BOTTOM w0.076: 137.03,85.36 137.02,85.35 136.46,85.35 136.36,85.38 136.08,85.38 135.99,85.35 135.8,85.35 135.66,85.41 UC1.N3
  BOTTOM w0.102: 137.03,85.36 137.06,85.36 137.72,86.02 139.29,86.02 TPC22.1
CFG19: length 6.8
  BOTTOM w0.076: 137.15,85.18 136.43,85.18 136.33,85.22 136.11,85.22 136.02,85.18 135.76,85.18 135.59,85.26 135.42,85.33 135.19,85.33 134.6,85.6 UC1.N4
  BOTTOM w0.102: TPC24.1 140.36,85.59 138.96,85.59 138.72,85.83 137.8,85.83 137.15,85.18
CFG_A1: length 3.6
  TOP w0.112: v2(25.55,125.52) RT13.2 RT17.2 23.4,125.27 23.4,124.65 23.24,124.48 UT2.1
CFG_A2: length 4.8
  TOP w0.112: v2(26.58,119.9) RT15.2 RT19.2 24.55,120.39 24.04,120.9 23.59,120.9 23.24,121.25 UT2.13
CFG_B1: length 2.4
  TOP w0.112: UT2.4 22.04,124.69 21.46,125.27 RT18.2 RT14.2
CFG_B2: length 2.9
  TOP w0.112: UT2.10 22.04,121.51 21.88,121.34 v2(21.88,120.82) RT20.2 RT16.2
CFG_RCOMP: length 12.4
  TOP w0.254: RC139.1 144.09,81.15 143.28,81.96 v2(141.87,81.96) 138.35,81.96 137.23,83.08 136.43,83.08 134.3,80.94 v1(134.16,80.94)
  BOTTOM w0.102: v1(134.16,80.94) 133.85,80.64 UC1.AB5
CHG_AMBER_LED_R#: length 14.5
  IN3 w0.135: v1(23.87,129.89) 23.94,129.82 27.94,129.82 28.29,130.17 29.82,130.17 30.13,130.49 31.15,130.49 v1(31.66,129.98)
  BOTTOM w0.112: v1(23.87,129.89) 23.87,129.12 22.65,127.9 Q2.2 ; Q15.6 30.78,130.85 v2(31.3,130.34) v1(31.66,129.98)
CLK_CNV_CRX_DTX_N: length 172.3
  IN1 w0.119: v1(75.34,120.45) 75.38,120.4 75.38,120.19 75.27,120.07 75.07,120.07 74.98,119.99 74.98,119.27 74.53,118.82 72.54,118.82 68.12,114.4 59.01,114.4 54.61,110.01 54.61,107.54 53.99,106.92 53.99,103 54.55,102.44 54.55,87.97 53.85,87.27 53.85,78.64 53.49,78.28 53.49,54.7 55.67,52.52 57.76,52.52 60.28,50 66.11,50 67.94,48.16 67.94,47 69.11,45.84 70.13,45.84 72.07,43.9 72.07,42.88 74.41,40.54 76.83,40.54 77.35,41.05 79.07,41.05 79.53,41.51 81.62,41.51 82.04,41.93 89.48,41.93 89.86,41.55 93.78,41.55 94.41,42.18 107.37,42.18 110.74,45.55 111.01,45.55 111.01,45.55 112.17,45.55 113.13,46.51 115.71,46.51 116.19,46.03 116.19,44.31 116.34,44.16 116.85,44.16 116.95,44.25 116.95,44.43 117.02,44.5 117.41,44.5 v1(117.41,44.5)
  BOTTOM w0.076: v1(117.41,44.5) 117,44.5 116.93,44.57 116.93,45.45 117.6,46.12 117.6,47.39 117.88,47.67 117.88,48.04 117.9,48.11 117.85,48.4 UC1.CN31
  BOTTOM w0.112: v1(75.34,120.45) 75.4,120.51 75.4,120.72 75.29,120.84 75.09,120.84 74.98,120.95 74.98,124.59 76.11,125.73 78.2,125.73 78.28,125.65 JWLAN1.21
CLK_CNV_CRX_DTX_P: length 172.1
  IN1 w0.119: v1(117.41,43.91) 117.38,43.94 116.25,43.94 115.97,44.22 115.97,45.94 115.62,46.29 113.22,46.29 112.26,45.33 110.92,45.33 110.83,45.33 107.46,41.96 94.5,41.96 93.87,41.33 89.77,41.33 89.39,41.71 82.13,41.71 81.71,41.29 79.62,41.29 79.16,40.83 77.44,40.83 76.92,40.32 74.32,40.32 71.85,42.79 71.85,43.81 70.04,45.62 69.02,45.62 67.73,46.91 67.73,48.07 66.02,49.78 60.19,49.78 57.67,52.3 55.58,52.3 53.27,54.61 53.27,78.37 53.63,78.73 53.63,87.36 54.33,88.07 54.33,102.35 53.78,102.91 53.78,107.01 54.39,107.63 54.39,110.1 58.91,114.62 68.03,114.62 72.45,119.04 74.44,119.04 74.76,119.36 v1(74.76,120.45)
  BOTTOM w0.076: UC1.CP31 117.72,48.03 117.72,47.74 117.43,47.46 117.43,46.19 116.76,45.52 116.76,44.5 116.94,44.33 117,44.33 117.08,44.25 117.08,43.95 117.2,43.82 117.32,43.82 v1(117.41,43.91)
  BOTTOM w0.112: JWLAN1.23 78.25,126.15 78.04,125.95 76.02,125.95 74.76,124.68 v1(74.76,120.45)
CLK_CNV_CTX_DRX_N: length 191.4
  IN1 w0.119: v1(114.87,45.03) 114.85,45.05 114.56,45.05 114.44,44.93 114.44,44.78 114.32,44.66 114.05,44.66 113.66,44.27 111.27,44.27 107.9,40.9 106.78,40.9 106.53,40.65 106.53,40.02 106.41,39.9 106.05,39.9 105.93,40.02 105.93,40.65 105.69,40.9 104.71,40.9 104.46,40.65 104.46,40.03 104.35,39.91 103.37,39.91 103.25,40.03 103.25,40.65 103.01,40.9 102.17,40.9 101.93,40.65 101.93,39.8 101.81,39.68 101.45,39.68 101.33,39.8 101.33,40.65 101.08,40.9 94.94,40.9 93.6,39.56 90.66,39.56 90.28,39.94 85.74,39.94 85.23,40.44 82.53,40.44 82.31,40.23 80.33,40.23 78.74,38.64 75.74,38.64 75.22,39.15 73.85,39.15 70.79,42.22 70.79,43.15 70.54,43.4 69.56,43.4 69.31,43.15 69.31,42.54 69.19,42.42 68.83,42.42 68.71,42.54 68.71,43.15 68.46,43.4 67.55,43.4 66.6,44.34 66.6,47.34 65.77,48.18 59.28,48.18 58.13,49.33 56.29,49.33 51.32,54.31 51.32,82.56 51.73,82.97 51.73,86.52 51.91,86.7 51.91,111.24 55.75,115.09 55.75,116.32 64.17,124.74 64.17,129.63 64.69,130.14 64.69,131.62 66.77,133.71 74.25,133.71 77,136.46 77,137.72 76.77,137.95 76.77,138.39 76.9,138.52 77.07,138.52 77.2,138.39 77.2,138.1 77.32,137.98 77.51,137.98 77.63,138.1 v1(77.63,138.16)
  BOTTOM w0.076: UC1.CP34 115.84,48.98 115.91,49.06 116.02,49.06 116.12,48.96 116.12,48.89 116.15,48.86 116.15,48.59 115.97,48.41 115.96,48.41 115.96,48.34 116.12,48.18 116.12,47.81 115.86,47.55 115.83,47.55 115.48,47.19 115.25,47.19 114.21,46.15 114.21,44.84 114.44,44.61 114.53,44.61 114.87,44.95 v1(114.87,45.03)
  BOTTOM w0.112: v1(77.63,138.16) 77.76,138.29 77.96,138.29 78.1,138.15 JWLAN1.71
CLK_CNV_CTX_DRX_P: length 191.3
  IN1 w0.119: v1(114.87,44.45) 114.14,44.45 113.75,44.05 111.36,44.05 107.99,40.68 106.87,40.68 106.75,40.56 106.75,39.93 106.5,39.68 105.96,39.68 105.71,39.93 105.71,40.56 105.59,40.68 104.8,40.68 104.68,40.56 104.68,39.94 104.44,39.69 103.28,39.69 103.04,39.94 103.04,40.56 102.92,40.68 102.26,40.68 102.14,40.56 102.14,39.71 101.9,39.46 101.36,39.46 101.11,39.71 101.11,40.56 100.99,40.68 95.03,40.68 93.69,39.34 90.57,39.34 90.19,39.72 85.65,39.72 85.14,40.23 82.62,40.23 82.4,40.01 80.43,40.01 78.84,38.42 75.64,38.42 75.13,38.93 73.76,38.93 70.57,42.12 70.57,43.06 70.45,43.18 69.65,43.18 69.53,43.06 69.53,42.45 69.28,42.2 68.74,42.2 68.49,42.45 68.49,43.06 68.37,43.18 67.46,43.18 66.39,44.25 66.39,47.25 65.68,47.96 59.19,47.96 58.04,49.12 56.2,49.12 51.1,54.22 51.1,82.65 51.51,83.06 51.51,86.61 51.69,86.79 51.69,111.33 55.53,115.18 55.53,116.41 63.95,124.83 63.95,129.72 64.47,130.23 64.47,131.71 66.68,133.92 74.15,133.92 76.78,136.55 76.78,137.63 76.55,137.85 76.55,138.48 76.81,138.74 77.63,138.74 v1(77.63,138.74)
  BOTTOM w0.076: v1(114.87,44.45) 114.37,44.45 114.04,44.77 114.04,46.22 115.19,47.36 115.41,47.36 115.76,47.71 115.79,47.71 115.96,47.88 115.96,48.11 115.55,48.51 115.55,49.09 UC1.CN34
  BOTTOM w0.112: v1(77.63,138.74) 77.83,138.54 77.99,138.54 78.1,138.65 JWLAN1.73
CLK_ITPXDP_N: length 5
  BOTTOM w0.102: 139.02,70.71 139.02,70.68 139.03,70.67 ; 139,70.73 138.84,70.89 137.77,70.89 137.37,71.28 136.3,71.28 136.22,71.2 136.22,71.06 136.32,70.96 UC1.AU1
  BOTTOM w0.112: 139.02,70.71 139,70.73 ; TP14.1 138.76,70 139.1,70 139.21,70.11 139.21,70.49 139.03,70.67
CLK_ITPXDP_P: length 5
  BOTTOM w0.102: UC1.AU2 136.03,71.1 136.03,71.28 136.23,71.47 137.45,71.47 137.84,71.08 138.93,71.08 139.18,70.83
  BOTTOM w0.112: 139.18,70.83 139.43,70.58 139.43,70.35 139.62,70.16 TP15.1
CLK_PCIE_N1: length 152.3
  IN1 w0.119: v1(140.96,69.01) 141.15,69.19 141.15,69.57 139.09,71.63 139.09,95.96 138.5,96.55 136.58,96.55 134.32,97.34 126.78,104.87 125.3,104.87 122.48,107.69 120.94,107.69 118.84,109.79 108.24,109.79 106.21,111.82 96.17,111.82 92.73,115.27 88.99,115.27 86.97,117.28 82.78,117.28 78.34,121.73 71.93,121.73 70.77,120.57 68.84,120.57 67.6,119.34 67.6,118.16 66.97,117.53 63.66,117.53 63.41,117.79 63.41,118.61 v1(63.19,118.83)
  BOTTOM w0.076: UC1.BC1 136.55,67.57 136.62,67.64 136.77,67.64 136.85,67.56 136.85,67.28 136.92,67.2 138.07,67.2 139,68.13 139.14,68.13 139.16,68.16 139.18,68.16
  BOTTOM w0.112: v1(63.19,118.83) 63.38,119.01 63.38,126.58 64.18,127.39 67.37,127.39 67.74,127.77 72.88,127.77 73.31,128.2 73.31,131.63 74.19,132.51 77.96,132.51 78.1,132.65 JWLAN1.49 ; 139.18,68.16 141.03,68.16 141.15,68.27 141.15,68.83 v1(140.96,69.01)
