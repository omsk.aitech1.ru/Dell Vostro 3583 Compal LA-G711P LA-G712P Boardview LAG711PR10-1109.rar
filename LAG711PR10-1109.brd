# Allegro board LAG711PR10-1109.brd (continued)
## Nets (continued)
DDR_B_DQS4: JDIMM2.179 UC1.AL30
DDR_B_DQS5: JDIMM2.200 UC1.AU30
DDR_B_DQS6: JDIMM2.221 UC1.BC30
DDR_B_DQS7: JDIMM2.242 UC1.BH30
DDR_B_DQS#0: JDIMM2.32 UC1.H24
DDR_B_DQS#1: JDIMM2.11 UC1.C23
DDR_B_DQS#2: JDIMM2.53 UC1.G30
DDR_B_DQS#3: JDIMM2.74 UC1.L30
DDR_B_DQS#4: JDIMM2.177 UC1.AL31
DDR_B_DQS#5: JDIMM2.198 UC1.AU31
DDR_B_DQS#6: JDIMM2.219 UC1.BC31
DDR_B_DQS#7: JDIMM2.240 UC1.BH31
DDR_B_MA0: JDIMM2.144 UC1.AG36
DDR_B_MA1: JDIMM2.133 UC1.AG35
DDR_B_MA2: JDIMM2.132 UC1.AF34
DDR_B_MA3: JDIMM2.131 UC1.AG37
DDR_B_MA4: JDIMM2.128 UC1.AE35
DDR_B_MA5: JDIMM2.126 UC1.AF35
DDR_B_MA6: JDIMM2.127 UC1.AE37
DDR_B_MA7: JDIMM2.122 UC1.AC29
DDR_B_MA8: JDIMM2.125 UC1.AE36
DDR_B_MA9: JDIMM2.121 UC1.AB29
DDR_B_MA10: JDIMM2.146 UC1.AG34
DDR_B_MA11: JDIMM2.120 UC1.AC28
DDR_B_MA12: JDIMM2.119 UC1.AB28
DDR_B_MA13: JDIMM2.158 UC1.AK35
DDR_B_ODT0: JDIMM2.155 UC1.AL36
DDR_B_ODT1: JDIMM2.161 UC1.AL34
DDR_B_PAR: JDIMM2.143 UC1.AE34
DDR_B_RAS#: JDIMM2.152 UC1.AJ34
DDR_B_WE#: JDIMM2.151 UC1.AJ35
DDR_DRAMRST#: RD8.2 RD9.2 UC1.BU31
DDR_DRAMRST#_R: CD26.1 JDIMM1.108 JDIMM2.108 RD9.1
DDR_VTT_CNTL: UC1.C35 UC2.2
DGPU_HOLD_RST#: RC107.1 UC1.CR22 UV2.2
DGPU_PWR_EN: PRV15.1 RC114.2 RC116.2 RZ5.1 RZ6.1 RZ7.1 UC1.CM24
DGPU_PWROK: PRV20.2 PRW01.1 RC68.2 UC1.CJ25 UV3.2
DIFFOUT_2PH_CPU: PRZ20.1 PRZ21.1 PUZ01.2
DIMM_CHA_SA0: JDIMM1.256 RD2.2 RD3.1
DIMM_CHA_SA1: JDIMM1.260 RD4.2 RD5.1
DIMM_CHA_SA2: JDIMM1.166 RD6.2 RD7.1
DIMM_CHB_SA0: JDIMM2.256 RD15.2 RD16.1
DIMM_CHB_SA1: JDIMM2.260 RD17.2 RD18.1
DIMM_CHB_SA2: JDIMM2.166 RD19.2 RD20.1
DMIC_CLK: LA5.2 UA1.3
DMIC_CLK_EDP: CA9.1 ED4.3 JEDP1.31 LA5.1
DMIC_DATA: RA4.2 UA1.2
DMIC_DATA_EDP: CA8.1 ED4.2 JEDP1.30 RA4.1
DP_VSSR: UV1.AF19 UV1.AF20 UV1.AF23 UV1.AG14 UV1.AG23 UV1.AH14 UV1.AM14 UV1.AM16 UV1.AM18 UV1.AM20 UV1.AM22 UV1.AM24
DRVON: PUA01.3 PUG01.16 PUI01.16 PUI02.16 PUZ01.35
EC_AGND: CE10.2 CE11.2 CE21.2 CE26.2 CE31.2 RE2.1 RE4.1 RE44.2 UE1.112
EC_MUTE#: RA12.2 RE29.2 UA1.40
EDP_AUXN: C17.1 UC1.AH4
EDP_AUXN_C: C17.2 JEDP1.16
EDP_AUXP: C19.1 UC1.AH3
EDP_AUXP_C: C19.2 JEDP1.15
EDP_BKLT_CTRL: D2.2 R11.2 UC1.CH11
EDP_COMP: RC4.2 UC1.AM6
EDP_HPD: JEDP1.12 R77.2 UC1.CM7
EDP_TXN0: C12.1 UC1.AG4
EDP_TXN0_C: C12.2 JEDP1.18
EDP_TXN1: C14.1 UC1.AG2
EDP_TXN1_C: C14.2 JEDP1.21
EDP_TXP0: C13.1 UC1.AG3
EDP_TXP0_C: C13.2 JEDP1.19
EDP_TXP1: C15.1 UC1.AG1
EDP_TXP1_C: C15.2 JEDP1.22
EDP_VDD_EN: D4.2 UC1.CG11
EMMC_RCOMP: RC64.1 UC1.CK15
EN_0.6VSP: PCM16.1 PRM09.2 PUM01.7
EN_1.2V: PCM15.1 PRM08.2 PUM01.8
EN_1.05V: PCH09.1 PRH01.2 PRH02.1 PUH01.6
EN_1.8V: PC1805.1 PR1801.2 PR1802.1 PU1801.5
EN_2.5V: PC2503.1 PR2501.1 PU2501.2
EN_3V: PR502.1 PU301.12
EN_5V: PC2506.1 PR503.1 PU501.12
EN_+1.35VGPU: PCW09.1 PRW01.2 PRW02.1 PUW01.6
EN_CPU: PRZ22.1 PUZ01.37
ENABLE_VGA: PRV15.2 PUV01.8
ENLDO_3V5V: PC317.1 PR302.1 PR303.1 PU301.11 PU501.11
ESPI_CLK: RC26.1 UC1.BV32
ESPI_CLK_R: CC3.1 JESPI1.10 RC26.2 RE39.2 UE1.57
ESPI_CS#: JESPI1.7 UC1.CA28 UE1.58
ESPI_IO0: RC192.1 UC1.CA29
ESPI_IO0_R: JESPI1.3 RC192.2 UE1.59
ESPI_IO1: RC193.1 UC1.BY29
ESPI_IO1_R: JESPI1.4 RC193.2 UE1.60
ESPI_IO2: RC194.1 UC1.BY27
ESPI_IO2_R: JESPI1.5 RC194.2 UE1.61
ESPI_IO3: RC195.1 UC1.BV27
ESPI_IO3_R: JESPI1.6 RC195.2 UE1.62
ESPI_RST#: RC205.2 UC1.CA27 UE1.53
EXT_PWR_GATE#: TP24.1(TP-1) UC1.CC37
FAN1_PWM: JFAN1.2 RE17.1 UE1.47
FAN1_TACH: CE28.1 JFAN1.3 RE16.1 UE1.40
FB_1.2V: PCM17.1 PRM10.1 PRM11.1 PUM01.6
FB_1.05V: PRH08.1 PRH09.1 PRH12.2 PUH01.10
FB_1.8V: PC1807.2 PR1805.1 PR1807.2 PU1801.6
FB_2PH_CPU: PCZ13.2 PCZ15.1 PRZ21.2 PRZ24.1 PUZ01.3
FB_3V: PC315.1 PR307.2 PR308.1 PU301.13
FB_3V_R: PC315.2 PR306.1
FB_5V: PC517.1 PR510.2 PR511.1 PU501.13
FB_5V_R: PC517.2 PR509.1
FB__+1.35VGPU: PRW09.1 PRW10.1 PRW13.2 PUW01.10
FB_GND: RV158.1 UV1.AD20
FB_VDDC: RV159.1 UV1.AC20
FB_VDDCI: TP73.1(TP-1) UV1.W1
FFS_INT1: RC27.2 UC1.CG22 US2.12
FFS_INT2: QS1.2 RC109.2 RS29.2 UC1.CH12 US2.11
FFS_INT2_Q: JHDD1.9 QS1.3 RS31.2
FPR_SCAN#: EU6.3 JFP1.2 R6.2 UE1.42
FSET_CHG: PRB38.1 PUB01.3
GPD7: RC58.2 UC1.BV35
GPIO19_CTF: RV151.1 UV1.M2
GPIO28: RV21.2 RV22.2 UV1.R5
GPP_A11: TP25.1(TP-1) UC1.CA32
GPP_B23: RC46.2 UC1.CC34
GPP_C2: RC38.2 UC1.CJ15
GPP_C5: RC44.2 UC1.CG15
GPP_H21: RC62.2 UC1.CF25
GPP_H23: RC65.2 UC1.CM26
GPU_PWR_LEVEL: RV80.1 UE1.10 UV1.T9
GPU_VID1: RV45.2 UV1.P8
GPU_VID3: RV44.2 UV1.N1
H_CPUPWRGD: RC76.2 UC1.AR2
H_CPUPWRGD_R: RC76.1 TP20.1(TP-1)
H_PECI: RE27.1 UE1.94
H_PROCHOT#: CE24.1 PQ11.1 PQ12.3 PQB32.1 PRB21.1 PRZ43.2 PRZ49.2 RC1.2 RC160.1 UE2.4
H_PROCHOT#_R: RC160.2 UC1.Y4
H_THERMTRIP#: RC2.2 UC1.BJ1
H_VCCST_PWRGD: CC71.1 RC99.1 RC145.2 UC8.4
HDA_BIT_CLK: CC6.1 RC48.2 UC1.BN37
HDA_BIT_CLK_R: RA8.2 RC48.1 UA1.5
HDA_SDIN0: RA7.1 UC1.BN35
HDA_SDIN0_R: RA7.2 UA1.7
HDA_SDOUT: RC49.2 RC50.2 RC51.2 UC1.BN36
HDA_SDOUT_R: RC49.1 UA1.4
HDA_SYNC: RC47.2 UC1.BN34
HDA_SYNC_R: RC47.1 UA1.9
HDD_DET#: RC206.2 RS33.1 UC1.CG20
HDD_DEVSLP: RS28.1 UC1.CP8
HDD_DEVSLP_R: JHDD1.8 RS28.2 RS33.2
HDMI_CLKN: CI1.2 LI1.2 RI5.1 RI23.1
HDMI_CLKP: CI2.2 LI1.3 RI1.1 RI24.1
HDMI_CTRL_CLK: JHDMI1.15 QI3.6 RI14.1
HDMI_CTRL_DAT: JHDMI1.16 QI3.3 RI15.1
HDMI_HPD: JHDMI1.19 QI2.1 RI16.1
HDMI_L_CLKN: JHDMI1.12 LI1.1 RI3.1 RI5.2
HDMI_L_CLKP: JHDMI1.10 LI1.4 RI1.2 RI3.2
HDMI_L_TX_N0: JHDMI1.9 LI2.1 RI2.2 RI4.1
HDMI_L_TX_N1: JHDMI1.6 LI4.1 RI10.1 RI12.2
HDMI_L_TX_N2: JHDMI1.3 LI3.1 RI9.1 RI11.2
HDMI_L_TX_P0: JHDMI1.7 LI2.4 RI4.2 RI6.2
HDMI_L_TX_P1: JHDMI1.4 LI4.4 RI8.2 RI10.2
HDMI_L_TX_P2: JHDMI1.1 LI3.4 RI7.2 RI9.2
HDMI_PLL_GND: QI1.1 RI17.2 RI18.2 RI19.2 RI20.2 RI21.2 RI22.2 RI23.2 RI24.2
HDMI_TX_N0: CI3.2 LI2.2 RI2.1 RI21.1
HDMI_TX_N1: CI5.2 LI4.2 RI12.1 RI17.1
HDMI_TX_N2: CI7.2 LI3.2 RI11.1 RI19.1
HDMI_TX_P0: CI4.2 LI2.3 RI6.1 RI22.1
HDMI_TX_P1: CI6.2 LI4.3 RI8.1 RI18.1
HDMI_TX_P2: CI8.2 LI3.3 RI7.1 RI20.1
HOST_DEBUG_TX: JDEG1.8 RE51.2 RW4.2 UE1.81
HPOUT_L: CA36.1 DA6.2 JHP1.1 LA2.2 RA34.1
HPOUT_R: CA35.1 DA6.3 JHP1.2 LA3.2 RA33.1
HW_ACAV_IN: CE32.2 PR31.1 PRB22.2 PRB25.2 PRB26.1 UE1.128
I2C_0_SCL: Q10.1 R37.2 UC1.CN11
I2C_0_SCL_R: JTP1.6 Q10.6 R43.2
I2C_0_SDA: Q10.4 R36.2 UC1.CM11
I2C_0_SDA_R: JTP1.7 Q10.3 R45.2
I2C_1_SCL: R85.1 R87.2 UC1.CJ12
I2C_1_SDA: R84.1 R86.2 UC1.CK12
I2C_3_SCL: JDB1.10 RC183.2 UC1.CH28
I2C_3_SDA: JDB1.9 RC182.2 UC1.CH27
I_ADP: CE26.1 RE46.1 UE1.110
I_ADP_R: PRB32.2 RE46.2
I_BATT: CE31.1 RE47.1 UE1.114
I_BATT_R: PCB10.1 PRB29.1 RE47.2
I_SYS: PRB33.2 PRZ11.2 PUZ01.46
ICCMAX_1A_CPU: PRZ67.1 PUZ01.19
ICCMAX_1B_CPU: PRZ68.1 PUZ01.20
ICCMAX_2PH_CPU: PRZ66.1 PUZ01.18
ICSP_CLK: RE53.2 UE1.101
ICSP_CLR: RE54.2 UE1.87
ICSP_DAT: RE55.2 UE1.102
ILIM_1A_CPU: PCZ32.1 PRZ56.1 PUZ01.27
ILIM_1B_CPU: PCZ05.1 PRZ05.1 PUZ01.42
ILIM_2PH_CPU: PRZ28.2 PUZ01.5
ILMT_1.05V: PRH03.2 PRH04.1 PUH01.12
IMON_VGA: PCV20.1 PRV16.1 PUV01.10
IMVP_VR_ON: PRZ22.2 RC148.2
INPUT3VSEL: RC103.2 RC104.1 UC1.BT27
INT_TP#: JTP1.4 Q8.3 R42.2
INTRUDER#: RC87.2 UC1.BR35
IO_CBL_DET#: JIOB1.9 R92.2 UC1.CM23
IOUT_1A_CPU: PCZ25.1 PRZ50.1 PUZ01.30
IOUT_1B_CPU: PCZ12.1 PRZ15.1 PUZ01.39
IOUT_2PH_CPU: PCZ14.1 PRZ23.1 PUZ01.1
ISEN1_VGA: PCV23.1 PRV22.2 PUV01.13
ISEN2_VGA: PCV22.1 PRV03.2 PUV01.12
ISOLATE#: RL8.2 RL9.1 UL1.20
IST_TRIG: TP32.1(TP-1) UC1.CP36
JACK_PLUG: DA7.3 JHP1.5 RA14.1
JACK_PLUG_DET: DA7.2 JHP1.6 RA35.1
JTAG_CLK: JDEG1.4 RE92.2
JTAG_TCK: RV19.1 UV1.L3
JTAG_TDI: JDEG1.2 RE53.1 RE90.2
JTAG_TDI_GPU: RP34.7 UV1.L5
JTAG_TDO: JDEG1.5 RE55.1 RE93.2
JTAG_TDO_GPU: RP34.8 UV1.K4
JTAG_TMS: JDEG1.3 RE54.1 RE91.2
JTAG_TMS_GPU: RP34.6 UV1.L1
JTAG_TRSTB: RP34.5 UV1.L6
KB_BL_CTRL#: JKBBL1.4 Q7.1
KB_DET#: JKB1.1 RC110.2 UC1.CM12
KB_LED_BL_DET: R38.1 R40.1 UC1.CK36
KB_LED_DET_C: JKBBL1.2 R38.2
KB_LED_PWM: Q7.2 UE1.44
KSI0: JKB1.9 RE66.2 UE1.98
KSI1: JKB1.7 RE67.2 UE1.99
KSI2: JKB1.5 RE68.2 UE1.6
KSI3: JKB1.8 RE69.2 UE1.7
KSI4: JKB1.4 RE73.2 UE1.104
KSI5: JKB1.6 RE72.2 UE1.105
KSI6: JKB1.3 RE71.2 UE1.107
KSI7: JKB1.2 RE70.2 UE1.108
KSO0: JKB1.18 RE74.2 UE1.2
KSO1: JKB1.16 RE75.2 UE1.14
KSO2: JKB1.17 RE76.2 UE1.15
KSO3: JKB1.15 RE77.2 UE1.16
KSO4: JKB1.11 RE78.2 UE1.37
KSO5: JKB1.10 RE79.2 UE1.38
KSO6: JKB1.13 RE80.2 UE1.39
KSO7: JKB1.12 RE81.2 UE1.50
KSO8: JKB1.14 RE86.2 UE1.46
KSO9: JKB1.24 RE18.1 UE1.68
KSO10: JKB1.26 RE82.2 UE1.72
KSO11: JKB1.25 RE83.2 UE1.74
KSO12: JKB1.19 RE84.2 UE1.75
KSO13: JKB1.22 RE85.2 UE1.76
KSO14: JKB1.23 RE88.2 UE1.77
KSO15: JKB1.21 RE87.2 UE1.86
KSO16: JKB1.20 RE89.2 UE1.92
LAN_MDIN0: TL1.15 UL1.2
LAN_MDIN1: TL1.9 UL1.5
LAN_MDIN2: TL2.10 UL1.7
LAN_MDIN3: TL2.16 UL1.10
LAN_MDIP0: TL1.16 UL1.1
LAN_MDIP1: TL1.10 UL1.4
LAN_MDIP2: TL2.9 UL1.6
LAN_MDIP3: TL2.15 UL1.9
LANWAKE#: RC93.2 UC1.BU32 UE1.35
LANXIN: RL2.2 UL1.28
LANXIN_R: CL1.1 RL2.1 YL1.1
LANXOUT: RL3.2 UL1.29
LANXOUT_R: CL7.1 RL3.1 YL1.3
LCD_BRIGHTNESS: JEDP1.27 R79.1
LCD_CBL_DET#: JEDP1.14 R90.2 UC1.CN14
LCD_TST: D2.3 R80.2 UE1.26
LCD_TST_C: JEDP1.10 R80.1
LCD_VCC_TEST_EN: D4.3 UE1.113
LCDVDD_EN: D4.1 R17.1 U1.4
LDO1_CAP: CA19.2 RA13.2 UA1.21
LDO2_CAP: CA21.2 UA1.32
LDO3_CAP: CA22.2 UA1.6
LED1: RL6.2 RL16.1 UL1.26
LG1_CHG: PQB25.4 PUB01.9
LG1_VGA: PQV01.6 PQV02.6 PUV01.24
LG2_VGA: PQV03.6 PQV04.6 PUV01.27
LG_1.2V: PQM01.8 PUM01.15
LG_VCCSA: PQA01.8 PUA01.5
LID_CL_SIO#: CE16.1 D3.1 R25.1 RE28.2 UE1.66
LID_CLOSE#: EC2.1 JPWR1.3 R25.2
LIMT_+1.35VGPU: PRW03.2 PRW04.1 PUW01.12
LINE1-L_C: CA33.2 RA28.1
LINE1-L_R: CA34.2 RA31.1
LINE1_L: CA33.1 UA1.18
LINE1_R: CA34.1 UA1.17
LOM_CABLE_DETECT: RL16.2 UE1.41
LOM_TCT: CL21.1 TL1.11 TL1.14 TL2.11 TL2.14
LX1_CHG: PCB06.2 PLB01.1 PQB25.5 PQB26.1 PQB26.2 PQB26.3 PRB40.1 PUB01.10
LX1_VGA: PCV21.2 PLV01.4 PQV01.7 PQV02.7 PRV23.1 PUV01.23
LX2_VGA: PCV08.2 PLV02.4 PQV03.7 PQV04.7 PRV06.1 PUV01.28
LX_1.2V: PCM12.2 PLM01.2 PQM01.9 PRM01.1 PUM01.16
LX_1.05V: PCH12.2 PLH01.1 PRH07.1 PUH01.2 PUH01.3
LX_1.8V: PL1801.1 PR1804.1 PU1801.2 PU1801.3
LX_3V: PC307.2 PL301.1 PR305.1 PU301.6 PU301.19 PU301.20
LX_5V: PC507.2 PL501.1 PR505.1 PU501.6 PU501.19 PU501.20
LX_+1.35VGPU: PCW12.2 PLW01.1 PRW07.1 PUW01.2 PUW01.3
LX_VCCSA: PCA07.2 PLA01.1 PQA01.9 PRA02.1 PUA01.7
LX_VCORE1: PLI01.1 PRI03.1 PUI01.11 PUI01.12
LX_VCORE2: PLI02.1 PRI23.1 PUI02.11 PUI02.12
LX_VGT1: PLG01.1 PRG03.1 PUG01.11 PUG01.12
M2_SSD_PEDET: JSSD1.69 RS1.2 UC1.CP10
M_ABIA0: UV1.L18 UV13.J4
M_ABIA1: UV1.K16 UV15.J4
M_CASA#0: UV1.G19 UV13.L3
M_CASA#1: UV1.G16 UV15.L3
M_CKEA0: UV1.K20 UV13.J3
M_CKEA1: UV1.J17 UV15.J3
M_CLKA0: RV78.2 UV1.H26 UV13.J12
M_CLKA1: RV85.2 UV1.G9 UV15.J12
M_CLKA#0: RV79.2 UV1.H25 UV13.J11
M_CLKA#1: RV86.2 UV1.H9 UV15.J11
M_CSA#0: UV1.H22 UV13.G12
M_CSA#1: UV1.G13 UV15.G12
M_DA0: UV1.K27 UV13.A2
M_DA1: UV1.J29 UV13.B2
M_DA2: UV1.H30 UV13.A4
M_DA3: UV1.H32 UV13.B4
M_DA4: UV1.G29 UV13.F2
M_DA5: UV1.F28 UV13.F4
M_DA6: UV1.F32 UV13.E4
M_DA7: UV1.F30 UV13.E2
M_DA8: UV1.C30 UV13.F11
M_DA9: UV1.F27 UV13.B13
M_DA10: UV1.A28 UV13.E11
M_DA11: UV1.C28 UV13.B11
M_DA12: UV1.E27 UV13.E13
M_DA13: UV1.G26 UV13.A13
M_DA14: UV1.D26 UV13.F13
M_DA15: UV1.F25 UV13.A11
M_DA16: UV1.A25 UV13.M4
M_DA17: UV1.C25 UV13.T4
M_DA18: UV1.E25 UV13.N4
M_DA19: UV1.D24 UV13.U4
M_DA20: UV1.E23 UV13.T2
M_DA21: UV1.F23 UV13.N2
M_DA22: UV1.D22 UV13.U2
M_DA23: UV1.F21 UV13.M2
M_DA24: UV1.E21 UV13.M11
M_DA25: UV1.D20 UV13.M13
M_DA26: UV1.F19 UV13.N13
M_DA27: UV1.A19 UV13.N11
M_DA28: UV1.D18 UV13.U13
M_DA29: UV1.F17 UV13.T13
M_DA30: UV1.A17 UV13.U11
M_DA31: UV1.C17 UV13.T11
M_DA32: UV1.E17 UV15.F4
M_DA33: UV1.D16 UV15.E4
M_DA34: UV1.F15 UV15.F2
M_DA35: UV1.A15 UV15.E2
M_DA36: UV1.D14 UV15.B4
M_DA37: UV1.F13 UV15.A2
M_DA38: UV1.A13 UV15.A4
M_DA39: UV1.C13 UV15.B2
M_DA40: UV1.E11 UV15.B11
M_DA41: UV1.A11 UV15.A11
M_DA42: UV1.C11 UV15.B13
M_DA43: UV1.F11 UV15.A13
M_DA44: UV1.A9 UV15.E11
M_DA45: UV1.C9 UV15.E13
M_DA46: UV1.F9 UV15.F11
M_DA47: UV1.D8 UV15.F13
M_DA48: UV1.E7 UV15.U2
M_DA49: UV1.A7 UV15.M2
M_DA50: UV1.C7 UV15.N2
M_DA51: UV1.F7 UV15.T2
M_DA52: UV1.A5 UV15.T4
M_DA53: UV1.E5 UV15.M4
M_DA54: UV1.C3 UV15.N4
M_DA55: UV1.E1 UV15.U4
M_DA56: UV1.G7 UV15.M11
M_DA57: UV1.G6 UV15.N11
M_DA58: UV1.G1 UV15.N13
M_DA59: UV1.G3 UV15.M13
M_DA60: UV1.J6 UV15.T13
M_DA61: UV1.J1 UV15.U13
M_DA62: UV1.J3 UV15.U11
M_DA63: UV1.J5 UV15.T11
M_DBIA0: UV1.H27 UV13.D2
M_DBIA1: UV1.A27 UV13.D13
M_DBIA2: UV1.C23 UV13.P2
M_DBIA3: UV1.C19 UV13.P13
M_DBIA4: UV1.C15 UV15.D2
M_DBIA5: UV1.E9 UV15.D13
M_DBIA6: UV1.C5 UV15.P2
M_DBIA7: UV1.H4 UV15.P13
M_EDCA0: UV1.H28 UV13.C2
M_EDCA1: UV1.C27 UV13.C13
M_EDCA2: UV1.A23 UV13.R2
M_EDCA3: UV1.E19 UV13.R13
M_EDCA4: UV1.E15 UV15.C2
M_EDCA5: UV1.D10 UV15.C13
M_EDCA6: UV1.D6 UV15.R2
M_EDCA7: UV1.G5 UV15.R13
M_MAA0_0: UV1.K17 UV13.H4
M_MAA0_1: UV1.J20 UV13.H5
M_MAA0_2: UV1.H23 UV13.H11
M_MAA0_3: UV1.G23 UV13.H10
M_MAA0_4: UV1.G24 UV13.K11
M_MAA0_5: UV1.H24 UV13.K10
M_MAA0_6: UV1.J19 UV13.K5
M_MAA0_7: UV1.K19 UV13.K4
M_MAA0_8: UV1.G20 UV13.J5
M_MAA1_0: UV1.J14 UV15.H4
M_MAA1_1: UV1.K14 UV15.H5
M_MAA1_2: UV1.J11 UV15.H11
M_MAA1_3: UV1.J13 UV15.H10
M_MAA1_4: UV1.H11 UV15.K11
M_MAA1_5: UV1.G11 UV15.K10
M_MAA1_6: UV1.J16 UV15.K5
M_MAA1_7: UV1.L15 UV15.K4
M_MAA1_8: UV1.G14 UV15.J5
M_RASA#0: UV1.G22 UV13.G3
M_RASA#1: UV1.G17 UV15.G3
M_WCKA0_0: UV1.E32 UV13.D4
M_WCKA0_1: UV1.A21 UV13.P4
M_WCKA1_0: UV1.E13 UV15.D4
M_WCKA1_1: UV1.E3 UV15.P4
M_WCKA#0_0: UV1.E30 UV13.D5
M_WCKA#0_1: UV1.C21 UV13.P5
M_WCKA#1_0: UV1.D12 UV15.D5
M_WCKA#1_1: UV1.F4 UV15.P5
M_WEA#0: UV1.G25 UV13.L12
M_WEA#1: UV1.H10 UV15.L12
MASK_BASE_LEDS#: Q15.2 Q15.5 R89.2 RE95.2
MASK_SATA_LED#: Q3.2 R26.2 RC158.1 UE1.56
MCT: CL20.1 RL12.1 RL13.1 RL14.1 RL15.1
MCT0: RL12.2 TL1.3
MCT1: RL13.2 TL1.6
MCT2: RL14.2 TL2.6
MCT3: RL15.2 TL2.3
ME_FWP: RC50.1 UE1.80
MEC_XTAL1: CE25.1 RE43.2 YE1.1
MEC_XTAL1_R: RE43.1 UE1.123
MEC_XTAL2: CE27.1 RE42.1 UE1.125 YE1.2
MEM_SMBCLK: QC1.6 RC198.2 UC1.CK14
MEM_SMBDATA: QC1.3 RC199.2 UC1.CH15
MIC_CAP: CA23.1 UA1.15
MODEL_ID: CE10.1 RE3.2 RE4.2 UE1.109
MSCLK: JDEG1.6 RE49.2
MSDATA: JDEG1.7 RE50.2 RE57.1
NB_MUTE#: RE29.1 UE1.119
NCT7718_DXN: C29.2 C30.2 Q13.3 U3.3
NCT7718_DXP: C29.1 C30.1 Q13.1 Q13.2 U3.2
NRB_BIT: RC112.2 UC1.CE29
NTC_CHG: PRB13.2 PUB01.13
PANEL_BKEN_EC: R78.2 UE1.117
PBAT_CHG_SMBCLK: PD5.3 PR42.2 PRB20.1 RE9.1 UE1.9
PBAT_CHG_SMBDAT: PD5.2 PR37.2 PRB19.1 RE8.1 UE1.8
PBAT_PRES#: CE18.1 PC14.1 PD6.2 PR39.2 PR41.1 PRB24.2 UE1.29
PBAT_PRES#_R: PBATT1.5 PR39.1
PCH_3.3V_TS_EN: R72.1 U2.4 UC1.CC30
PCH_BATLOW#: RC96.2 UC1.BV36
PCH_DPWROK: RC101.2 UC1.BP30
PCH_JTAG_TCK1: RC157.1 TPC3.1(TP-1) UC1.W6
PCH_PCIE_WAKE#: RC92.2 RC102.2 UC1.BU30
PCH_PLTRST#: UC1.BJ35 UC4.1 UC4.2
PCH_POPIRCOMP: RC16.1 UC1.BW25
PCH_PRIM_EN: PR1801.1 RZ4.1 RZ8.2
PCH_RSMRST#: RE26.1 UC5.1 UE1.27
PCH_RSMRST#_Q: RC75.2 RC101.1 RC155.1 UC1.BR36 UC5.4
PCH_RTCRST#: CC8.1 CLRP2.1 RC82.2 UC1.BR34
PCH_RTCX1: CC11.1 RC95.2 UC1.BN31 YC2.1
PCH_RTCX2: CC12.1 RC95.1 UC1.BN32 YC2.2
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JVGA1.12 QC1.1 RC29.2 US2.1
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JVGA1.11 QC1.4 RC28.2 US2.4
PCH_SRTCRST#: CC7.1 CLRP1.1 RC77.2 UC1.BR37
PCIE_CRX_C_DTX_N9: CL9.2 UL1.18
PCIE_CRX_C_DTX_P9: CL8.2 UL1.17
PCIE_CRX_DTX_N9: CL9.1 UC1.BP5
PCIE_CRX_DTX_N10: JWLAN1.43 UC1.BN6
PCIE_CRX_DTX_N13: JSSD1.5 UC1.BK6
PCIE_CRX_DTX_N14: JSSD1.17 UC1.BJ6
PCIE_CRX_DTX_N15: JSSD1.29 UC1.BG5
PCIE_CRX_DTX_N16: JSSD1.43 UC1.BE5
PCIE_CRX_DTX_P9: CL8.1 UC1.BP6
PCIE_CRX_DTX_P10: JWLAN1.41 UC1.BN5
PCIE_CRX_DTX_P13: JSSD1.7 UC1.BK5
PCIE_CRX_DTX_P14: JSSD1.19 UC1.BJ5
PCIE_CRX_DTX_P15: JSSD1.31 UC1.BG6
PCIE_CRX_DTX_P16: JSSD1.41 UC1.BE6
PCIE_CTX_C_DRX_N9: CL14.2 UL1.14
PCIE_CTX_C_DRX_N10: CW6.2 JWLAN1.37
PCIE_CTX_C_DRX_N13: CS7.2 JSSD1.11
PCIE_CTX_C_DRX_N14: CS9.2 JSSD1.23
PCIE_CTX_C_DRX_N15: CS11.2 JSSD1.35
PCIE_CTX_C_DRX_N16: CS13.2 JSSD1.47
PCIE_CTX_C_DRX_P9: CL13.2 UL1.13
PCIE_CTX_C_DRX_P10: CW5.2 JWLAN1.35
PCIE_CTX_C_DRX_P13: CS8.2 JSSD1.13
PCIE_CTX_C_DRX_P14: CS10.2 JSSD1.25
PCIE_CTX_C_DRX_P15: CS12.2 JSSD1.37
PCIE_CTX_C_DRX_P16: CS14.2 JSSD1.49
PCIE_CTX_DRX_N9: CL14.1 UC1.BR2
PCIE_CTX_DRX_N10: CW6.1 UC1.BR4
PCIE_CTX_DRX_N13: CS7.1 UC1.BM4
PCIE_CTX_DRX_N14: CS9.1 UC1.BL2
PCIE_CTX_DRX_N15: CS11.1 UC1.BL4
PCIE_CTX_DRX_N16: CS13.1 UC1.BJ4
PCIE_CTX_DRX_P9: CL13.1 UC1.BR1
PCIE_CTX_DRX_P10: CW5.1 UC1.BR3
PCIE_CTX_DRX_P13: CS8.1 UC1.BM3
PCIE_CTX_DRX_P14: CS10.1 UC1.BL1
PCIE_CTX_DRX_P15: CS12.1 UC1.BL3
PCIE_CTX_DRX_P16: CS14.1 UC1.BJ3
PCIE_RCOMPN: RC126.2 UC1.CE6
PCIE_RCOMPP: RC126.1 UC1.CE5
PCIE_WAKE#: JSSD1.54 RC102.1 RW10.1 UE1.4 UL1.21
PCIE_WAKE#_R: JWLAN1.55 RW10.2
PECI_EC: DE1.1 RE27.2 UC1.AR1
PEG_CRX_C_GTX_N5: CV2.2 UV1.AG31
PEG_CRX_C_GTX_N6: CV4.2 UV1.AF28
PEG_CRX_C_GTX_N7: CV6.2 UV1.AF26
PEG_CRX_C_GTX_N8: CV8.2 UV1.AD26
PEG_CRX_C_GTX_P5: CV1.2 UV1.AH30
PEG_CRX_C_GTX_P6: CV3.2 UV1.AG29
PEG_CRX_C_GTX_P7: CV5.2 UV1.AF27
PEG_CRX_C_GTX_P8: CV7.2 UV1.AD27
PEG_CRX_GTX_N5: CV2.1 UC1.BW9
PEG_CRX_GTX_N6: CV4.1 UC1.BU6
PEG_CRX_GTX_N7: CV6.1 UC1.BT7
PEG_CRX_GTX_N8: CV8.1 UC1.BU9
PEG_CRX_GTX_P5: CV1.1 UC1.BW8
PEG_CRX_GTX_P6: CV3.1 UC1.BU5
PEG_CRX_GTX_P7: CV5.1 UC1.BT6
PEG_CRX_GTX_P8: CV7.1 UC1.BU8
PEG_CTX_C_GRX_N5: CV10.1 UV1.AE31
PEG_CTX_C_GRX_N6: CV12.1 UV1.AD28
PEG_CTX_C_GRX_N7: CV14.1 UV1.AC31
PEG_CTX_C_GRX_N8: CV16.1 UV1.AB28
PEG_CTX_C_GRX_P5: CV9.1 UV1.AF30
PEG_CTX_C_GRX_P6: CV11.1 UV1.AE29
PEG_CTX_C_GRX_P7: CV13.1 UV1.AD30
PEG_CTX_C_GRX_P8: CV15.1 UV1.AC29
PEG_CTX_GRX_N5: CV10.2 UC1.BW4
PEG_CTX_GRX_N6: CV12.2 UC1.BU4
PEG_CTX_GRX_N7: CV14.2 UC1.BU2
PEG_CTX_GRX_N8: CV16.2 UC1.BT4
PEG_CTX_GRX_P5: CV9.2 UC1.BW3
PEG_CTX_GRX_P6: CV11.2 UC1.BU3
PEG_CTX_GRX_P7: CV13.2 UC1.BU1
PEG_CTX_GRX_P8: CV15.2 UC1.BT3
PHASE_VCORE1: PCI09.2 PUI01.7
PHASE_VCORE2: PCI29.2 PUI02.7
PHASE_VGT1: PCG09.2 PUG01.7
PLL_ANALOG_IN: TP74.1(TP-1) UV1.AA1
PLL_ANALOG_OUT: RV83.1 UV1.AA3
PLT_RST_VGA#: RV4.1 UE1.23 UV1.AL27 UV2.4 UV3.1
PLTRST#: CC75.1 JSSD1.50 JWLAN1.52 RC94.1 RE65.1 UC4.4 UL1.19 UV2.1 UX1.17
POK: CC14.1 DZ2.1 PR35.1 PR304.2 PR504.2 PU301.9 PU501.9 RC105.1 UC5.2
POWER_SW#_MB: EC1.1 ED1.3 JPWR1.2 RE25.2 SW1.1
POWER_SW_IN#: CE14.1 RE20.2 RE25.1 UE1.127
PRIM_PWRGD: PR1803.2 PRH01.1 PU1801.4 UE1.30
PRIMCORE_VID0: TP28.1(TP-1) UC1.CB36
PRIMCORE_VID1: TP29.1(TP-1) UC1.CB35
PROCHOT: RE45.2 UE1.83 UE2.2
PROG_CHG: PRB17.2 PUB01.19
PROH: PQB33.2 PRB21.2 PRB44.2 PUB01.23
PROJECT_ID1: RC52.2 RC55.1 UC1.CK19
PROJECT_ID2: RC200.2 RC201.1 UC1.CG17
PROJECT_ID3: RC53.2 RC56.1 UC1.CN20
PS_0: CV28.1 RV8.2 RV9.1 UV1.AC19
PS_1: CV29.1 RV11.2 RV12.1 UV1.AD19
PS_2: CV30.1 RV13.2 RV14.1 UV1.AE17
PS_3: CV31.1 RV15.2 RV16.1 UV1.AE20
PS_ID: PD2.1 PR1.2 PR5.1 UE1.36
PSID: PJPDC1.3 PL3.1
PSID-1: PQ2.2 PR3.2 PR6.1
PSID-2: PD1.2 PL3.2 PQ1.1 PR3.1
PSID-3: PQ1.3 PR1.1
PTP_DIS#: D5.1 UE1.90
PWM1_2PH_CPU: PUI01.1 PUZ01.16
PWM2_2PH_CPU: PUI02.1 PUZ01.17
PWM_1A_CPU: PUG01.1 PUZ01.22
PWM_1B_CPU: PUA01.2 PUZ01.36
PWRGD_VGA: PRV17.2 PRV20.1 PRV37.1 PUV01.20
PX_EN: TP79.1(TP-1) UV1.AB16
QPCN_CHG: PCB18.2 PUB01.6
QPCP_CHG: PCB18.1 PUB01.4
REFCLK_CNV: JWLAN1.64 RC84.2
REFCLK_CNV_R: RC84.1 RC86.1 UC1.CM3
REGOUT: CL2.1 RL1.1 UL1.24
RESET_OUT#: CE30.1 RE24.1 UC1.BP31 UE1.73
RING2: LA1.1 RA25.2 UA1.13
RING2_R: CA37.1 CA39.1 DA5.3 JHP1.4 LA1.2
RJ45_MDIN0: JLAN1.2 TL1.2
RJ45_MDIN1: JLAN1.6 TL1.8
RJ45_MDIN2: JLAN1.5 TL2.7
RJ45_MDIN3: JLAN1.8 TL2.1
RJ45_MDIP0: JLAN1.1 TL1.1
RJ45_MDIP1: JLAN1.3 TL1.7
RJ45_MDIP2: JLAN1.4 TL2.8
RJ45_MDIP3: JLAN1.7 TL2.2
ROSC_COREGT_CPU: PRZ64.1 PUZ01.14
ROSC_SAUS_CPU: PRZ60.1 PUZ01.15
RTC_DET#: Q1.1 RC111.2 UC1.CP22
RTCRST_ON: C33.1 D8.1 Q17.2 R64.2 R65.2 UE1.31
RTCRST_ON_R: C2.1 D8.2 Q18.2 R64.1
RUNPWROK: RE41.2 UE1.48
SATA_CRX_C_DTX_N0: CS17.2 JHDD1.5
SATA_CRX_C_DTX_N1: CO6.1 JODD1.9 JODD1.10
SATA_CRX_C_DTX_P0: CS18.2 JHDD1.6
SATA_CRX_C_DTX_P1: CO7.1 JODD1.11 JODD1.12
SATA_CRX_DTX_N0: CS17.1 UC1.BN10
SATA_CRX_DTX_N1: CO6.2 UC1.BL6
SATA_CRX_DTX_P0: CS18.1 UC1.BN8
SATA_CRX_DTX_P1: CO7.2 UC1.BL5
SATA_CTX_C_DRX_N0: CS16.2 JHDD1.3
SATA_CTX_C_DRX_N1: CO5.1 JODD1.5 JODD1.6
SATA_CTX_C_DRX_P0: CS15.2 JHDD1.2
SATA_CTX_C_DRX_P1: CO4.1 JODD1.3 JODD1.4
SATA_CTX_DRX_N0: CS16.1 UC1.BN4
SATA_CTX_DRX_N1: CO5.2 UC1.BN2
SATA_CTX_DRX_P0: CS15.1 UC1.BN3
SATA_CTX_DRX_P1: CO4.2 UC1.BN1
SATA_LED#: Q16.2 RC127.1 RS34.2 UC1.CN7
SATA_LED#_R: Q3.3 Q16.3 R30.2
SATA_ODD_DA#: JODD1.23 JODD1.24 TP55.1(TP-1)
SATA_ODD_PRSNT#: JODD1.15 JODD1.16 RO1.1 UC1.CM10
SCLK_CPU: PRZ46.1 PUZ01.34
SD_RCOMP: RC54.2 UC1.CK33 UC1.CM34
SD_READ_MODE: JIOB1.1 RC115.2 UC1.CA30
SDIO_CPU: PRZ48.1 PUZ01.32
SEL: QT1.3 RT12.2 UT2.16
SIO_EXT_WAKE#: RC113.2 UC1.CN12 UE1.116
SIO_PWRBTN#: RC98.2 UC1.BU28 UE1.52
SIO_SLP_A#: TP23.1(TP-1) UC1.BU37
SIO_SLP_LAN#: TP21.1(TP-1) UC1.BT31
SIO_SLP_S0#: TP16.1(TP-1) UC1.BJ37
SIO_SLP_S3#: CZ41.1 DZ4.1 RC10.2 RC144.1 RZ2.1 TP17.1(TP-1) UC1.BU36 UC9.1 UZ3.3 UZ3.5
SIO_SLP_S4#: CC76.1 DZ5.1 DZ7.1 PR2501.2 RC11.2 RZ1.1 RZ9.1 TP18.1(TP-1) UC1.BU27
SIO_SLP_S5#: PQB29.2 UC1.BT29
SIO_SLP_SUS#: TP19.1(TP-1) UC1.BU29
SIO_SLP_WLAN#: TP22.1(TP-1) UC1.BT30
SKTOCC#: RC173.1 UC1.E1
SLEEVE: LA4.1 RA26.2 UA1.14
SLEEVE_R: CA38.1 CA40.1 DA5.2 JHP1.3 LA4.2
SM_RCOMP0: RC17.1 UC1.BN28
SM_RCOMP1: RC18.1 UC1.BN27
SM_RCOMP2: RC20.1 UC1.BN29
SML0_SMBCLK: RC33.2 UC1.CH14
SML0_SMBDATA: RC34.2 UC1.CF15
SML1_SMBCLK: Q11.3 QV1.6 RC196.2 RE11.1 UC1.CN15 UE1.12
SML1_SMBDATA: Q11.6 QV1.3 RC197.2 RE10.1 UC1.CM15 UE1.11
SN_1.2V: PCM11.1 PRM01.2
SN_1.05V: PCH13.1 PRH07.2
SN_3V: PC309.1 PR305.2
SN_5V: PC509.1 PR505.2
SNB_VCCSA: PCA09.1 PRA02.2
SNUB1_CHG: PCB29.1 PRB40.2
SNUB_+1.35VGPU: PCW13.1 PRW07.2
SOC_XDP_TDI: RC151.2 TPC5.1(TP-1) UC1.U5 UC1.U6
SOC_XDP_TDO: RC152.2 TPC1.1(TP-1) UC1.W5 UC1.Y5
SOC_XDP_TMS: RC150.2 TPC4.1(TP-1) UC1.P5 UC1.T5
SOC_XDP_TRST#: TPC6.1(TP-1) UC1.AB6 UC1.Y6
SPI_CLK_ROM: RC40.1 RC45.2 UC3.6
SPI_CLK_ROM2: RC178.1 UC11.6
SPI_CLK_TPM: RX9.2 UX1.19
SPI_D0_ROM: RC42.1 UC3.5
SPI_D0_ROM2: RC180.1 UC11.5
SPI_D0_TPM: RX6.2 UX1.21
SPI_D1_ROM: RC43.1 UC3.2
SPI_D1_ROM2: RC179.1 UC11.2
SPI_D1_TPM: RX5.2 UX1.24
SPI_D2_ROM: RC39.2 UC3.3
SPI_D2_ROM2: RC177.2 UC11.3
SPI_D3_ROM: RC41.2 UC3.7
SPI_D3_ROM2: RC181.2 UC11.7
SPKR: DA3.2 RC57.2 UC1.CF35
SSD_DEVSLP: JSSD1.38 UC1.CM8
SSD_SCP#: RE60.1 RS2.2 RS29.1 UE1.21
SUSCLK: RC79.1 RC80.1 UC1.BT32
SUSCLK_EC: RC80.2 RE42.2
SUSCLK_WLAN: JWLAN1.50 RC79.2
SVI2_SVC: PUV01.3 RV45.1 RV84.1 RV89.2 RV157.2
SVI2_SVD: PUV01.5 RV44.1 RV87.1 RV88.2 RV155.2
SVI2_SVT: PUV01.7 RV156.2
SYS_LED_MASK#: RE95.1 UE1.55
SYS_PWROK: CC79.2 RE22.1 UC1.CR10 UE1.28
SYS_RESET#: RC100.2 UC1.CN10
SYSPWR_PRES: RE30.1 RE32.1 UE1.120
T_CRIT#: R55.2 U3.4
TESTEN: RV17.2 RV18.2 UV1.K7
THM_SML1_CLK: Q11.4 R50.2 U3.8
THM_SML1_DATA: Q11.1 R49.2 U3.7
TON_1.2V: PRM07.2 PUM01.9
TOUCH_I2C_DET#: RC208.2 RC209.1 UC1.CC29
TOUCH_PAD_INT#: DZ1.2 RC5.2 UC1.CB34
TOUCH_PANEL_PD#: RC6.2 RC14.2 UC1.CC35
TOUCH_SCREEN_INT#: JEDP1.24 RC203.2 UC1.CN3
TOUCH_SCREEN_PD#: D3.2 R14.2 RC14.1
TOUCH_SCREEN_RST: JEDP1.25 R88.2 UC1.CP4
TP_EN#: R41.1 UE1.49
TP_LOCK#: D5.2 JTP1.3 R46.2
TP_WAKE_KBC#: DZ1.1 Q8.1 RE12.1 UE1.33
TPM_ID: RC59.2 RC63.1 UC1.CK25
TPM_SPI_IRQ#: RX1.2 UC1.CF20 UX1.18
TPS25810_EN: RT9.1 UE1.89 UT1.6
TPS25810_POL#: QT1.2 RT10.1 UE1.91 UT1.18
TPS25810_UFP#: RT11.1 UE1.32 UT1.19
TS_EN: C18.1 JEDP1.39 R14.1
TSENSE_1PH_CPU: PCZ36.1 PRZ63.1 PUZ01.23
TSENSE_1PH_CPU_R: PHZ05.1 PRZ63.2 PRZ65.1
TSENSE_2PH_CPU: PCZ22.1 PRZ34.2 PUZ01.11
TSENSE_2PH_CPU_R: PHZ04.1 PRZ34.1 PRZ36.1
TYPEC_CC1: EU11.2 JUSBC1.A5 UT1.11
TYPEC_CC2: EU11.3 JUSBC1.B5 UT1.13
UART1_CTS#: TP27.1(TP-1) UC1.CG14
UART1_RTS#: TP26.1(TP-1) UC1.CF12
UG1_CHG: PQB26.4 PUB01.11
UG1_VGA: PQV01.1 PQV02.1 PUV01.22
UG2_VGA: PQV03.1 PQV04.1 PUV01.29
UG_1.2V: PQM01.1 PUM01.17
UG_VCCSA: PQA01.1 PUA01.8
USB2_COMP: RC123.1 UC1.CC5
USB2_ID: RC124.1 UC1.CE8
USB2_VBUSSENSE: RC125.1 UC1.CC6
USB3_1_MRX_DTX_N4: EU8.2 EU8.8 JUSBC1.B10 UT2.3
USB3_1_MRX_DTX_P4: EU8.1 EU8.9 JUSBC1.B11 UT2.2
USB3_1_MTX_C_DRX_N4: CT8.2 EU8.5 EU8.6 JUSBC1.A3
USB3_1_MTX_C_DRX_P4: CT7.2 EU8.4 EU8.7 JUSBC1.A2
USB3_1_MTX_DRX_N4: CT8.1 UT2.7
USB3_1_MTX_DRX_P4: CT7.1 UT2.6
USB3_2_MRX_DTX_N4: EU9.1 EU9.9 JUSBC1.A10 UT2.8
USB3_2_MRX_DTX_P4: EU9.2 EU9.8 JUSBC1.A11 UT2.9
USB3_2_MTX_C_DRX_N4: CT10.2 EU9.4 EU9.7 JUSBC1.B3
USB3_2_MTX_C_DRX_P4: CT9.2 EU9.5 EU9.6 JUSBC1.B2
USB3_2_MTX_DRX_N4: CT10.1 UT2.11
USB3_2_MTX_DRX_P4: CT9.1 UT2.12
USB3_CRX_C_MTX_N4: CT4.2 UT2.17
USB3_CRX_C_MTX_P4: CT5.2 UT2.18
USB3_CRX_DTX_N1: LU3.3 RU6.2 UC1.CB5
USB3_CRX_DTX_N2: LU6.3 RU12.2 UC1.BY8
USB3_CRX_DTX_P1: LU3.2 RU4.2 UC1.CB6
USB3_CRX_DTX_P2: LU6.2 RU10.2 UC1.BY9
USB3_CRX_L_DTX_N1: EU1.1 EU1.9 JUSB1.5 LU3.4 RU6.1
USB3_CRX_L_DTX_N2: EU3.1 EU3.9 JUSB2.5 LU6.4 RU12.1
USB3_CRX_L_DTX_P1: EU1.2 EU1.8 JUSB1.6 LU3.1 RU4.1
USB3_CRX_L_DTX_P2: EU3.2 EU3.8 JUSB2.6 LU6.1 RU10.1
USB3_CRX_MTX_N4: CT4.1 UC1.BW6
USB3_CRX_MTX_P4: CT5.1 UC1.BW5
USB3_CTX_C_DRX_N1: CU2.2 LU2.3 RU5.2
USB3_CTX_C_DRX_N2: CU15.2 LU5.3 RU11.2
USB3_CTX_C_DRX_P1: CU1.2 LU2.2 RU3.2
USB3_CTX_C_DRX_P2: CU14.2 LU5.2 RU9.2
USB3_CTX_C_MRX_N4: CT3.2 UT2.15
USB3_CTX_C_MRX_P4: CT2.2 UT2.14
USB3_CTX_DRX_N1: CU2.1 UC1.CA4
USB3_CTX_DRX_N2: CU15.1 UC1.CA2
USB3_CTX_DRX_P1: CU1.1 UC1.CA3
USB3_CTX_DRX_P2: CU14.1 UC1.CA1
USB3_CTX_L_DRX_N1: EU1.4 EU1.7 JUSB1.8 LU2.4 RU5.1
USB3_CTX_L_DRX_N2: EU3.4 EU3.7 JUSB2.8 LU5.4 RU11.1
USB3_CTX_L_DRX_P1: EU1.5 EU1.6 JUSB1.9 LU2.1 RU3.1
USB3_CTX_L_DRX_P2: EU3.5 EU3.6 JUSB2.9 LU5.1 RU9.1
USB3_CTX_MRX_N4: CT3.1 UC1.BW2
USB3_CTX_MRX_P4: CT2.1 UC1.BW1
USB20_N1: LU1.2 RU1.1 UC1.CE3
USB20_N1_R: EU2.2 JUSB1.2 LU1.1 RU1.2
USB20_N2: LU4.3 RU8.1 UC1.CE1
USB20_N2_R: EU4.3 JUSB2.2 LU4.4 RU8.2
USB20_N3: LU8.2 RU16.1 UC1.CG3
USB20_N3_R: JIOB1.7 LU8.1 RU16.2
USB20_N4: R57.1 R59.1 UC1.CD3
USB20_N4_R: EU10.3 JUSBC1.A7 JUSBC1.B7 LT1.4 RT21.2
USB20_N4_RR: LT1.3 R57.2 RT21.1
USB20_N5: EU5.3 JFP1.6 UC1.CG5
USB20_N6: L3.4 R12.2 UC1.CC1
USB20_N6_R: ED3.2 JEDP1.33 L3.3 R12.1
USB20_N7: LU7.3 RU14.1 UC1.CG8
USB20_N7_R: JIOB1.4 LU7.4 RU14.2
USB20_N8: R61.1 UC1.CB8
USB20_N8_R: ED2.3 JEDP1.36 L4.3 R19.1 R84.2
USB20_N8_RR: L4.4 R19.2 R59.2 R61.2
USB20_N10: JWLAN1.5 UC1.CC3
USB20_P1: LU1.3 RU2.1 UC1.CE4
USB20_P1_R: EU2.3 JUSB1.3 LU1.4 RU2.2
USB20_P2: LU4.2 RU7.1 UC1.CE2
USB20_P2_R: EU4.2 JUSB2.3 LU4.1 RU7.2
USB20_P3: LU8.3 RU15.1 UC1.CG4
USB20_P3_R: JIOB1.6 LU8.4 RU15.2
USB20_P4: R58.1 R60.1 UC1.CD4
USB20_P4_R: EU10.2 JUSBC1.A6 JUSBC1.B6 LT1.1 RT22.2
USB20_P4_RR: LT1.2 R58.2 RT22.1
USB20_P5: EU5.2 JFP1.5 UC1.CG6
USB20_P6: L3.1 R10.2 UC1.CC2
USB20_P6_R: ED3.3 JEDP1.34 L3.2 R10.1
USB20_P7: LU7.2 RU13.1 UC1.CG9
USB20_P7_R: JIOB1.3 LU7.1 RU13.2
USB20_P8: R62.1 UC1.CB9
USB20_P8_R: ED2.2 JEDP1.37 L4.2 R18.1 R85.2
USB20_P8_RR: L4.1 R18.2 R60.2 R62.2
USB20_P10: JWLAN1.3 UC1.CC4
USB_EN#: RE19.1 UE1.13 UU1.4 UU2.4
USB_OC0#: RC189.1 UC1.CK6 UU1.3
USB_OC1#: RC190.1 UC1.CK5 UU2.3
USB_OC2#: RC191.1 UC1.CK8
USB_OC3#: RC188.1 RT5.2 UC1.CK9
VCI_IN1#: RE31.1 UE1.126
VCIN0_PH: C31.1 C32.1 R52.2 RE34.2 RH1.1
VCREF0: CE19.1 RE35.2 RE40.1 UE1.25
VD_IN1_C: C31.2 C32.2 R53.1 RH1.2
VGA_CBL_DET#: JVGA1.7 R91.2 UC1.CR24
VGA_POK: PRV37.2 PUV01.9 RV165.1 RV166.2
VGA_SMB_CK3: QV1.1 RV6.2 UV1.U7
VGA_SMB_DA3: QV1.4 RV5.2 UV1.U8
VIDALERT#: RC135.1 UC1.AA3
VIDALERT_N: PRZ41.2 PRZ47.2 RC134.2 RC135.2
VIDSCLK: PRZ40.2 PRZ46.2 UC1.AA1
VIDSOUT: PRZ42.2 PRZ48.2 RC136.2 UC1.AA2
VL: PC515.1 PU501.15
VR_CAP: CE23.1 UE1.18
VR_HOTL#: PRZ49.1 PUZ01.31
VRAM_ID1: RC118.2 RC120.1 UC1.CE27
VRAM_ID2: RC117.2 RC119.1 UC1.CN23
VRAM_RST#: CV97.1 RV37.1 RV38.1 UV1.L10
VRAM_RST#_R: RV36.1 UV13.J2 UV15.J2
VRMP_CPU: PCZ23.1 PRZ35.2 PUZ01.12
VSA_SEN+: PRZ03.1 RC164.2 UC1.BG7
VSA_SEN-: PRZ07.1 RC165.1 UC1.BE7
VSN_1A_CPU: PCZ28.1 PRZ52.1 PUZ01.25
VSN_1A_CPU_R: PCZ28.2 PCZ29.1 PRZ52.2 PRZ53.1
VSN_1B_CPU: PCZ07.2 PRZ08.2 PUZ01.44
VSN_2PH_CPU: PCZ11.2 PRZ19.2 PUZ01.48
VSN_2PH_CPU_R: PCZ10.2 PCZ11.1 PRZ18.2 PRZ19.1
VSNN_1B_CPU_R: PCZ06.2 PCZ07.1 PRZ07.2 PRZ08.1
VSP_1A_CPU: PCZ35.2 PRZ58.2 PUZ01.24
VSP_1A_CPU_R: PCZ29.2 PRZ58.1 PRZ59.2 PRZ61.1
VSP_1B_CPU: PCZ04.2 PRZ04.2 PUZ01.45
VSP_2PH_CPU: PCZ10.1 PRZ14.2 PUZ01.47
VSPP_1B_CPU_R: PCZ04.1 PCZ06.1 PRZ03.2 PRZ04.1
VSUM+_VGA: PCV28.1 PCV30.1 PRV07.2 PRV24.2 PRV28.1 PRV30.1 PUV01.14
VSUM-_VGA: PCV22.2 PCV23.2 PCV28.2 PCV30.2 PCV32.1 PHV02.2 PRV08.2 PRV25.2 PRV30.2 PRV33.1 PRV35.1
VTTREF_1.2V: PCM19.1 PUM01.4
WAKEB: RV162.2 RV163.1 UV1.AJ27
WHITE_LED_BAT: C21.1 Q4.1 R27.2
WIFI_RF_EN: DW2.1 RC175.2 UC1.CG25
WIFI_RF_EN_R: DW2.2 JWLAN1.56
XCLK_BIASREF: RC83.1 UC1.CJ1
XDP_BPM#0: TP2.1(TP-1) UC1.U1
XDP_BPM#1: TP3.1(TP-1) UC1.U2
XDP_BPM#2: TP4.1(TP-1) UC1.U3
XDP_BPM#3: TP5.1(TP-1) UC1.U4
XDP_HOOK0: RC155.2 TPC10.1(TP-1)
XDP_HOOK3: RC32.1 RC149.2 TPC8.1(TP-1)
XDP_ITP_PMODE: RC153.2 TPC7.1(TP-1) UC1.W4
XDP_PRDY#: TP8.1(TP-1) UC1.W1
XDP_PREQ#: TP7.1(TP-1) UC1.W2
XDP_PRSENT_CPU: RC154.2 TPC9.1(TP-1)
XTAL24_IN: RC89.1 UC1.CK3
XTAL24_IN_R: CC9.1 RC89.2 RC90.1 YC1.3
XTAL24_OUT: RC91.1 UC1.CK2
XTAL24_OUT_R: CC10.1 RC90.2 RC91.2 YC1.1
XTALIN: CV17.1 RV20.1 UV1.AM28 YV1.1
XTALOUT: CV18.1 RV20.2 UV1.AK28 YV1.3
N12281337: RA10.2 UA1.10
N16741477: TP67.1(TP-1) UV1.AB8
N16741489: TP63.1(TP-1) UV1.AD7
N16741505: TP69.1(TP-1) UV1.AB4
N16741517: TP61.1(TP-1) UV1.AD9
N16741525: TP71.1(TP-1) UV1.Y8
N16741803: RV29.2 UV1.AC22
N16741825: RV59.2 UV1.AB22
N16751828: TP64.1(TP-1) UV1.AC8
N16751830: TP60.1(TP-1) UV1.AE8
N16751834: TP58.1(TP-1) UV1.AE9
N16751836: TP56.1(TP-1) UV1.N9
N16751838: TP70.1(TP-1) UV1.AB2
N16751842: TP66.1(TP-1) UV1.AB9
N16751844: TP62.1(TP-1) UV1.AC10
N16751848: TP57.1(TP-1) UV1.L9
N16751852: TP68.1(TP-1) UV1.AB7
N16751854: TP65.1(TP-1) UV1.AC7
N16751856: TP59.1(TP-1) UV1.Y11
N16751858: TP72.1(TP-1) UV1.Y7
N16808781: RV157.1 UV1.AJ11
N16808782: RV155.1 UV1.AK12
N16808783: RV156.1 UV1.AL11
N16813004: RV25.2 RV26.1 RV84.2 RV87.2
N17003752: JDIMM1.134 RD1.2
N17004366: JDIMM2.134 RD14.2
N17283936: QA1.3 RA2.1 RA5.1
N17389450: PC516.1 PD501.2 PR502.2 PR503.2 PR506.2 PR508.1
N17415515: PJP2.1 PJPDC1.1 PJPDC1.2 PL2.1
N17446666: Q6.1 R39.2
N17462309: JDEG1.9 RE52.2
N17462311: JDEG1.1 RE48.2
N17462343: JESPI1.8 RE65.2
N17746338: RX10.2 RX18.1 RX19.1
N17746442: CX5.1 CX6.1 CX7.1 RX15.1 RX16.1 UX1.22
N17747394: RC171.1 UC1.G3 UC1.G4
N17747798: RC172.1 UC1.C34
N17847259: TP78.1(TP-1) UV1.AL9
N17877344: TP75.1(TP-1) UV1.R1
N17877347: TP76.1(TP-1) UV1.R3
N18346552: C23.2 Q5.2 Q6.2 R41.2
N18855880: R15.2 U1.3
N18983262: CE20.2 RE39.1
N18984098: CA20.2 RA8.1
N19343283: JSSD1.8 RS2.1
N19639840: QS1.5 QS1.6 RS30.2
N19855003: CZ36.2 UZ6.10
N19855015: CZ35.2 UZ6.12
N19855442: CZ28.1 UZ5.6
N19964578: RZ10.2 UZ7.4
N19964609: RZ12.1 UZ7.6
N20135010: PCV33.2 PRV33.2 PUV01.15
N20135022: PCV33.1 PRV35.2
N20135024: PCV11.1 PRV13.2 PUV01.25
N20135039: PRV19.1 PUV01.11
N20135040: PCV25.1 PCV27.1 PRV29.1 PRV34.2 PUV01.16
N20135043: PCV34.1 PRV36.2 PUV01.17
N20135126: PHV01.1 PRV18.1 PRV19.2
N20135134: PCV26.1 PRV26.2 PRV29.2 PRV31.1 PRV32.1 PUV01.18
N20135137: PCV25.2 PRV26.1
N20135139: PCV31.1 PRV32.2
N20135141: PCV26.2 PCV29.2 PRV27.1 PUV01.19
N20135144: PCV29.1 PRV31.2
N20135171: PHV02.1 PRV28.2
N20135248: PUV01.39 PUV01.40
N20135251: PRV02.1 PUV01.36 PUV01.37 PUV01.38
N20135257: PRV10.1 PUV01.1
N20135258: PRV09.1 PUV01.2
N20135263: PRV04.1 PUV01.34
N20135264: PRV05.1 PUV01.32 PUV01.33
N20756305: QT1.5 QT1.6 RT23.2
N21269026: PCI32.1 PRI23.2
N21273981: PCG12.1 PRG03.2
N21379353: PC508.1 PU501.16 PU501.17
N22856216: TP53.1(TP-1) UL1.27
N22856217: TP54.1(TP-1) UL1.25
N22856235: RL7.2 UL1.31
N22856250: RL10.2 UL2.3
N23133643: PDB01.1 PRB15.1
N24460345: PD501.1 PR507.2
N24550044: PCV24.1 PRV23.2
N24550059: PCV21.1 PRV21.2
N24550063: PLV01.3 PRV22.1 PRV24.1
N24550065: PLV01.2 PRV25.1
N24550138: PLV02.3 PRV03.1 PRV07.1
N24550140: PCV09.1 PRV06.2
N24550153: PCV08.1 PRV01.2
N24550158: PLV02.2 PRV08.1
N24557362: TP77.1(TP-1) UV1.U6
N24610461: PCH11.1 PRH11.2 PUH01.11
N24610467: PCH10.1 PUH01.9
N24610523: PCH14.2 PRH12.1
N24610920: PRH05.2 PUH01.7
N24874892: PRB19.2 PUB01.21
N24874930: PRB20.2 PUB01.22
N25136715: DI1.3 RI14.2
N25136716: DI1.2 RI15.2
N25241223: RV121.1 UV15.J13
N25241225: RV117.1 UV15.J1
N25241231: RV119.1 UV15.J10
N25397464: CC5.2 RC45.1
N25403147: JDB1.4 RB7.1
N25403151: JDB1.8 RB9.1
N25403157: JDB1.14 RB10.1
N25403161: JDB1.18 RB11.1
N25403175: JDB1.3 RB1.2
N25403185: JDB1.5 RB2.2
N25403191: JDB1.7 RB3.2
N25403203: JDB1.17 RB5.2
N25403205: JDB1.19 RB6.2
N25403207: JDB1.13 RB4.2
N25403817: JDB1.6 RB8.1
N25728593: Q18.1 R63.2
N25766780: TP34.1(TP-1) UC1.CR35
N25941897: CZ20.1 RZ4.2 UZ4.3
N25941919: CZ22.1 UZ4.6
N26325502: CC50.1 UC1.BP24
N26532121: JWLAN1.6 TP51.1(TP-1)
N26532122: JWLAN1.16 TP52.1(TP-1)
N26604037: RV166.1 UV3.4
N28160180: Q16.5 Q16.6 R31.2
N28160287: LED1.4 R28.1
N28160289: LED1.2 R27.1
N28162955: DA4.2 RA29.1
N28162971: DA4.3 RA32.1
N28248044: CC68.1 DZ4.2 RC144.2 UC6.2
N28248145: CZ6.1 UZ1.12
N28248150: CZ7.1 UZ1.10
N28372404: RX10.1 UX1.1
N28372567: RX11.2 UX1.2
N28373080: TP80.1(TP-1) UX1.6
N28373361: TP81.1(TP-1) UX1.7
N28373436: RX12.1 UX1.8
N28373601: RX13.1 UX1.16
N28373753: RX14.1 UX1.23
N28405142: RX17.1 RX20.1 UX1.14
N28406092: JSSD1.10 RS34.1
N28483977: PQ13.2 PR31.2 PR35.2 PR45.1
N28483985: PQ13.3 PR32.2
N28484391: PC13.1 PQ12.6 PR33.2
N28484395: PC13.2 PQ12.5 PR40.1
N28484412: PQ12.2 PR36.2 PR44.2
N28484439: PC14.2 PQ11.2 PR43.1
N28484451: PQ13.5 PQ13.6 PR34.2 PR38.1
N28606987: RX21.2 UX1.9
N28607577: RX22.2 UX1.32
N28610747: RT4.1 UT1.9
N28610884: RT7.1 UT1.16
N28610886: RT6.1 UT1.20
N28610888: RT5.1 UT1.1
N28610904: RT8.1 UT1.17
N28610914: RT3.2 UT1.8
N28610924: RT4.2 UT1.10
N28610938: RT2.2 UT1.7
N28766144: PRB29.2 PUB01.27
N28767446: PRB27.2 PRB28.2 PUB01.26
N28810503: CZ16.1 UZ3.12
N28810563: CZ17.1 UZ3.10
N28866422: PRB02.3 PRB12.1
N28866424: PRB31.1 PUB01.29
N28866425: PCB13.1 PRB31.2 PRB32.1
N28866427: PRB33.1 PRB34.1 PUB01.30
N28866460: PRB01.3 PRB37.2
N28866517: PRB01.2 PRB36.2
N28866577: PCB11.1 PRB30.2
N28866586: PCB06.1 PRB14.2
N28866613: PRB02.2 PRB11.1
N29056076: PQB28.2 PQB29.1
N29179188: PCB01.1 PQB11.1 PQB11.2 PQB11.3 PQB12.1 PQB12.2 PQB12.3 PQB30.3 PRB03.1 PRB08.1
N29179461: PCB70.1 PQB12.5 PRB02.1
N29179498: PQB11.4 PRB06.1
N29179534: PCB01.2 PQB12.4 PQB30.1 PRB06.2 PRB07.1
N32437553: RV123.1 UV13.J13
N33188643: CA32.1 RA23.2 RA24.1
N35136189: PQB30.2 PRB03.2 PRB04.1
N35174703: PQB33.1 PRB42.2 PRB43.1
N35174707: PCB36.1 PQB32.2 PRB43.2
N36085760: PD3.1 PR7.2
N36085833: PQ1.2 PQ2.1 PR4.2 PR7.1
N37640332: RV2.2 UV1.N10
N37640410: RV3.1 UV1.AA22
N37828209: RV1.1 UV1.Y22
N38038746: CV96.1 RV36.2 RV37.2
N38038992: CV98.2 UV1.K8
N38038994: CV99.2 UV1.L7
N38038995: CV98.1 RV40.2
N38038996: CV99.1 RV41.2
N38349725: RV39.2 UV1.K25
N38996077: RV134.1 UV13.J1
N38996080: RV135.1 UV13.J10
N40664383: JDIMM1.165 TP47.1(TP-1)
N40665360: JDIMM2.165 TP49.1(TP-1)
N40665398: JDIMM2.162 TP48.1(TP-1)
N41527020: JDIMM1.162 TP46.1(TP-1)
N45784517: PCZ02.1 PCZ08.1 PCZ09.1 PRZ06.2 PUZ01.41
N45784764: PRZ16.2 PUZ01.38
N45784907: PCZ26.2 PCZ27.2 PCZ33.1 PRZ51.2 PUZ01.28
N45784946: PCZ01.2 PRZ01.1
N45784991: PCZ13.1 PRZ20.2
N45785219: PCZ35.1 PRZ61.2
N45789065: PCI12.1 PRI03.2
N47599587: PCZ16.1 PRZ24.2
N47727863: PCW11.1 PRW11.2 PUW01.11
N47727869: PCW10.1 PUW01.9
N47735962: PRW05.2 PUW01.7
N47772279: PCZ31.2 PRZ55.1
N47887852: PC1806.1 PR1804.2
N48572231: PCW14.2 PRW13.1
N124752685: CD27.2 RD13.1
N124753277: CD52.2 RD24.1
N124859178: TP1.1(TP-1) UC1.AM7
N295954310: PHZ01.2 PRZ10.1

Pads without a net: ED1 2; EU6 2; FD1 1; FD2 1; FD3 1; FD4 1; JDB1 21 22 23 24; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 5 6 9; JHDMI1 13 14; JKB1 28 29; JKBBL1 3; JSSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; JUSBC1 A8 B8; JWLAN1 8 12 20 38 40 42 44 46 48 58 60 62 66 68 70; PD1 3; PD6 3; PJPDC1 4; PU301 10 15; PU501 10; PU1801 1 7; PU2501 5; PUG01 6 13 17 19; PUI01 6 13 17 19; PUI02 6 13 17 19; PUV01 4 35; TL1 4 5 12 13; TL2 4 5 12 13; U2 3; UC1 A34 A35 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AE1 AE2 AE3 AE4 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC24 BC28 BE1 BE2 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL35 BL36 BL37 BP8 BP9 BP34 BP35 BR18 BT8 BT9 BU34 BV24 BV25 BV28 BV29 BV30 BV34 BW34 BW35 BW36 BW37 BY3 BY4 BY6 BY7 BY30 BY31 BY32 CA34 CA35 CA36 CA37 CC27 CC32 CC36 CE28 CE31 CF22 CF27 CF29 CF31 CG1 CG2 CG23 CH4 CH5 CH6 CH7 CH8 CH9 CH17 CH20 CH22 CH23 CH25 CH30 CH32 CH35 CH36 CJ17 CJ22 CJ27 CJ29 CJ30 CJ31 CK17 CK22 CK23 CK34 CL35 CL36 CM16 CM18 CM19 CM20 CM27 CM28 CM35 CN4 CN8 CN16 CN18 CN19 CN22 CN24 CN26 CN28 CN35 CN36 CP3 CP6 CP7 CP12 CP16 CP18 CP20 CP24 CP26 CP28 CR3 CR4 CR8 CR12 CR14 CR16 CR18 CR20 CR26 CR28 D34 D35 D37 F34 F37 G1 G2 H3 H4 K12 K14 K15 K17 K18 K20 L5 L25 M24 M26 N5 P24 P26 R24 R25 R26 T25 V24 V25 W3 W25 Y3 Y24 Y25; UC2 1; UC6 1; UC8 1; UE1 24 34 63 70 71 96 97; UE2 1; UV1 AA5 AA6 AA29 AA31 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC16 AC23 AC25 AD2 AD4 AD10 AD11 AD13 AD16 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF22 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK10 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM10 AM12 AM26 J8 J22 J25 K13 K30 L16 L17 L29 L31 M4 M27 M28 M30 N3 N5 N6 N8 N26 N29 N31 P2 P4 P7 P10 P23 P24 P26 P27 P28 P30 R6 R29 R31 T2 T4 T7 T8 T23 T24 T26 T27 T28 T30 U5 U23 U24 U26 U29 U31 V2 V4 V6 V27 V28 V30 W3 W5 W6 W7 W8 W23 W24 W29 W31 Y2 Y4 Y6 Y23 Y24 Y26 Y27 Y28 Y30; UV13 A5 U5; UV15 A5 U5; UX1 3 4 5 10 11 12 13 15 25 26 27 28 29 30 31; YC1 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 5898 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 732 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 168 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 57 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 171.3
  TOP w0.112: v1(44.67,106.17) 41.25,102.74 41.25,102.55 v1(40.17,101.47) ; UC2.4 107.11,108.88 106.97,109.02 CC2.1 RC19.2 108.67,109.46 v2(109.2,109.99) 109.25,110.04 v1(109.25,112.9)
  TOP w0.254: v1(33.18,31.56) 32.98,31.56 32.73,31.31 PRM09.1
  IN2 w0.124: v1(40.17,101.47) 36.86,98.17 36.86,92.01 34.26,89.4 34.26,87.27 35.47,86.06 35.47,76.51 34.2,75.24 30.74,75.24 29.6,74.1 29.6,73.43 29.94,73.08 31.02,73.08 32.04,72.07 32.04,66.23 30.35,64.54 30.35,64.02 31.25,63.12 31.25,61.62 31.87,61 37.39,61 37.74,60.65 37.74,56.75 35.7,54.71 35.7,40.36 34.93,39.59 34.93,37.67 33.56,36.3 33.56,33.08 33.18,32.7 v1(33.18,31.56) ; v1(109.25,112.9) 108.46,112.1 87.65,112.1 85.63,114.12 56.3,114.12 49.17,106.99 45.5,106.99 v1(44.67,106.17)
1.0V_VCCST_EN: length 5.2
  BOTTOM w0.112: UZ1.3 130.24,107.01 CZ3.1 RZ1.2 130.25,107.89 DZ5.2 v2(130.25,110.23)
1.2V_VTT_PWRGD: length 73.6
  TOP w0.203: 34.55,27.62 v1(34.55,27.62) ; 34.55,27.62 34.55,27.75 34.81,28.01 PUM01.10 ; 34.55,27.62 34.55,27.43 33.79,26.66 PRM06.2 ; RC147.1 92.15,44.76 v1(90.78,43.4) 89.98,42.59 CC77.2 ; v1(46.64,33.21) 50.29,36.85 54.58,36.85 57.46,39.73 v2(64.96,39.73) 65.8,39.73 v1(66.14,40.07)
  IN2 w0.203: v1(66.14,40.07) 68.99,40.07 69.11,39.95 76.29,39.95 76.9,39.34 77.84,39.34 80.27,41.77 81.35,41.77 82.02,42.45 89.77,42.45 90.72,43.4 v1(90.78,43.4)
  IN3 w0.254: v1(34.55,27.62) 34.8,27.36 40.05,27.36 41.46,28.78 44.5,28.78 46.64,30.92 v1(46.64,33.21)
+0.6V_DDR_VTT: length 32
  TOP w1.016: 61.46,40.91 71.62,40.91 72.55,41.84
  TOP w1.524: 40.36,37.02 41.16,37.82 54.18,37.82 58.71,42.35
  vias: v1(60.3,43.24) v1(60.93,43.24) v1(72.49,43.05) v1(73.12,43.05) v3(59.98,41.7)
+0.6VSP:
  vias: v3(38.71,31.68)
+0.95VSDGPU: length 23.3
  TOP w0.508: RV30.1 112.24,127.42 v1(111.55,126.73) ; v1(117.83,119.82) 117.83,119.38 v3(118.8,118.4) 120.88,116.32 123.09,116.32 123.25,116.16 125.13,116.16 125.29,116.32 132.81,116.32 134.1,117.61 LV8.1
  vias: v1(116.56,119.82) v1(117.19,119.82) v1(120.42,144.74) v1(120.46,144.16) v1(120.91,145.27)
+0.95VSDGPU_ON: length 3
  BOTTOM w0.112: UZ6.3 119.43,108.64 v2(119.55,108.52) 119.67,108.4 CZ32.2 RZ6.2
+0.95VSDGPU_OUT:
  vias: v2(121.4,111.45)
+1.2V_DDR: length 156
  TOP w0.381: UC2.5 105.81,109.34 CC1.1
  TOP w0.508: CD45.1 57.72,79.94 v1(56.92,80.74) ; v1(59.69,96.74) 59.66,96.71 CD48.1 ; v1(59.52,53.37) 58.69,53.37 CD43.1 ; v1(67.98,70.84) 67.63,70.49 CD49.1 ; v1(69.58,78.13) 69.59,78.15 CD19.1 ; v1(80.58,102.02) 80.01,102.02 79.99,102.04 CD18.1 ; 78.33,106.74 78.34,106.75 78.34,112.53 79.03,113.22 82.2,113.22 84.48,110.94 100.3,110.94 101.78,109.46 CC1.1 ; CD46.1 68.87,106.23 v1(68.87,105.93) ; RD1.1 72.49,76.62 v1(72.73,76.39) ; CD44.1 57.21,75.88 v1(56.98,76.1) ; v1(67.98,76.69) 67.96,76.67 CD50.1 ; v1(68.49,58.14) 68.16,58.46 CD42.1 ; CD47.1 56.93,106.85 v1(56.91,106.82) ; v1(56.88,78.03) 58.72,78.03 59.04,77.71 RD14.1 ; RD21.1 57.98,67.88 57.09,68.77 v1(56.93,68.77) ; v1(69.65,69.06) 69.65,67.99 70.15,67.48 RD10.1
  IN3 w0.508: v1(56.92,80.74) 56.17,79.99 56.17,69.53 v1(56.93,68.77)
  BOTTOM w0.09: v1(113.34,81.62) 113.35,81.63 UC1.Y36 ; v1(113.34,76.6) UC1.AH36 ; UC1.AY36 v1(113.34,69.05) ; v1(113.34,74.08) UC1.AM36
  BOTTOM w0.102: UC1.AD36 v1(113.34,79.12)
  BOTTOM w0.2: UC1.AW32 117.27,69.75 v1(117.27,69.81) ; v1(117.31,73.45) 116.91,73.06 UC1.AN32
  BOTTOM w0.203: UC1.R32 116.91,84.9 117.34,85.33 117.34,85.35 v1(117.35,85.35) ; v1(113.32,63.99) 113.35,63.95 114.27,63.95 UC1.BH36
  BOTTOM w0.254: v1(117.32,66.18) 116.91,65.77 UC1.BE32 ; JDIMM2.163 67.4,67.49 67.66,67.75 67.66,68.25 67.42,68.49 ; v1(117.31,77.11) 116.91,76.71 UC1.AH32
  BOTTOM w0.305: JDIMM1.111 79.15,82.49 80.29,82.49 80.68,82.1 v1(80.68,81.64) ; v1(67.73,74.78) 67.51,74.99 66.45,74.99 JDIMM2.141 ; v1(68.11,78.16) 67.93,77.99 JDIMM2.129 ; v1(59.69,96.74) JDIMM2.54 ; v1(69.68,52.75) 69.68,52.93 69.99,53.24 JDIMM1.220 ; JDIMM1.153 80.16,69.99 80.46,69.68 v1(80.46,69.08) 80.46,68.7 80.25,68.49 JDIMM1.159 ; v1(72.23,96.74) JDIMM1.54 ; v1(56.33,86.27) 57.39,86.27 57.43,86.24 JDIMM2.96 ; JDIMM1.75 80.23,91.49 v1(80.44,91.28) ; JDIMM1.178 69.41,63.74 v1(69.38,63.77) ; JDIMM2.112 58.25,82.24 v1(56.92,82.24) 56.92,82.24 ; v1(80.55,47.52) 80.55,47.65 80.21,47.99 JDIMM1.241 ; JDIMM1.154 70.95,69.74 70.02,69.74 69.7,70.06 v1(69.7,70.84) ; JDIMM2.33 66.45,101.99 v1(67.94,101.99) ; JDIMM2.111 67.45,82.49 67.75,82.18 v1(67.75,81.81) ; JDIMM1.118 69.93,80.74 69.63,81.04 v1(69.63,81.81) 69.63,81.93 69.93,82.24 JDIMM1.112 ; JDIMM1.124 70.06,79.24 69.58,78.76 v1(69.58,78.13) 69.58,78.02 69.86,77.74 70.95,77.74 JDIMM1.130 ; v1(80.43,79.95) 80.43,80.8 80.23,80.99 JDIMM1.117 ; v1(56.91,106.82) 57.32,107.24 JDIMM2.12 ; v1(80.58,102.02) 80.55,101.99 JDIMM1.33 ; v1(68.83,85.66) 69.41,86.24 JDIMM1.96 ; JDIMM2.199 66.45,58.49 68.13,58.49 v1(68.49,58.14) ; JDIMM2.241 67.93,47.99 v1(68.36,47.56) ; v1(68.87,105.93) 68.87,106.48 69.62,107.24 JDIMM1.12 ; JDIMM2.178 60.03,63.74 v1(60.11,63.81) ; v1(67.98,76.69) 67.78,76.49 JDIMM2.135 ; JDIMM2.75 67.54,91.49 v1(67.85,91.17) ; v1(69.52,74.78) 69.52,75.86 69.9,76.24 JDIMM1.136 72.58,76.24 v1(72.73,76.39) ; JDIMM2.147 67.63,71.49 67.98,71.14 v1(67.98,70.84) 67.98,70.51 67.46,69.99 JDIMM2.153 ; JDIMM2.123 67.57,79.49 68.02,79.93 v1(68.02,79.93) 68.02,80.61 67.63,80.99 JDIMM2.117 ; JDIMM1.199 78,58.49 v1(77.65,58.14) ; JDIMM1.163 80.59,67.49 v1(81.19,66.89) ; v1(67.73,69.06) 67.73,68.79 67.42,68.49 JDIMM2.159 ; v1(59.52,53.37) 59.39,53.24 JDIMM2.220 ; JDIMM1.160 69.9,68.24 69.65,68.5 v1(69.65,69.06)
  vias: v1(42.59,33.17) v1(42.92,33.7) v1(43.23,33.17) v1(43.56,33.7) v1(43.86,33.17) v1(44.19,33.7) v1(44.5,33.17) v1(44.8,33.7) v1(45.11,33.17) v1(45.44,33.7) v1(46.04,52.83) v1(46.04,52.2) v1(46.05,53.47) v1(46.07,51.62) v1(46.08,50.97) v1(46.08,50.34) v1(46.07,49.74) v1(46.07,49.14) v1(46.08,33.71) v1(46.77,53.65) v1(46.77,53.02) v1(46.77,52.38) v1(46.77,51.75) v1(46.77,51.11) v1(46.77,50.48) v1(46.77,49.84) v1(46.77,49.21) v1(67.5,73.52) v1(80.48,78.25) v3(102.69,96.36)
+1.2VP: length 11.7
  TOP w0.203: PUM01.19 38.78,29.21 39.14,29.56
  TOP w0.381: 39.48,31.17 39.14,30.83 39.14,29.56
  IN3 w0.508: v1(44.48,31.17) 43.91,30.6 36.53,30.6 v1(35.9,31.24)
  vias: v1(52.4,32.55) v1(52.76,30.77) v1(52.76,30.18) v1(53.01,32.55) v1(53.35,30.77) v1(53.35,30.18) v1(53.64,32.55) v1(53.93,30.77) v1(53.93,30.18) v1(54.52,30.77) v1(54.52,30.18) v1(55.1,30.77) v1(55.1,30.18) v2(45.09,31.28)
+1.05V_MPHY: length 3.7
  BOTTOM w0.203: v1(129.07,56.95) UC1.BY14 ; v1(129.07,56.95) UC1.BW14 v1(128.23,56.95) ; v1(129.07,56.95) UC1.BW12 ; v1(129.07,56.95) UC1.BY12 ; UC1.BV12 v1(129.07,58.25) UC1.BV14
  vias: v3(128.62,56.54)
+1.05V_MPHYPLL: length 11.3
  TOP w0.508: v1(137.35,58.15) 138.69,59.49 v3(141.72,59.49) 144.17,59.49 CC53.1 144.43,59.76 CC54.1 144.43,62.16
  BOTTOM w0.18: v1(137.35,58.15) 137.31,58.15 137.26,58.1 UC1.BV2
+1.05V_PRIM: length 244.6
  TOP w0.203: CE15.1 35.47,85.28 36.23,84.51 v1(36.67,84.51) 37.55,84.51 37.75,84.31 UE1.95
  TOP w0.508: v1(148.63,54.82) v3(148.63,58.92) 148.63,60.13 146.59,62.16 RC129.1
  IN1 w0.508: v1(142.27,105.79) 142.27,105.79 143.44,104.62 143.44,99.16 144.04,98.56 144.04,85.54 145.32,84.26 v1(145.89,84.26)
  IN2 w0.124: v1(45.37,104.83) 46.77,106.23 49.37,106.23 56.58,113.44 85.35,113.44 87.37,111.43 113.19,111.43 115.06,113.3 119.29,113.3 120.23,112.36 122.37,112.36 126.34,108.39 v1(128.81,108.39)
  IN3 w0.135: v1(36.67,84.51) 36.89,84.29 44.77,84.29 46.14,85.66 46.14,93.66 47.39,94.91 47.39,97.61 45.37,99.63 v1(45.37,104.83)
  IN3 w0.508: v1(145.89,84.26) 146.08,84.26 146.98,83.36 146.98,81.92 145.64,80.58 145.64,75.96 144.79,75.11 144.79,72.61 146.99,70.41 146.99,67.03 148.95,65.08 148.95,55.14 v1(148.63,54.82)
  BOTTOM w0.203: 124.03,56.95 UC1.BW22 v1(124.03,57.6) ; 124.03,56.95 UC1.BW20 ; 124.03,56.95 UC1.BY20 ; UC1.BW16 v1(126.55,56.95) ; UC1.BW16 v1(126.55,57.6) ; UC1.BW16 v1(127.4,57.61) ; v1(126.55,56.95) UC1.BY16 UC1.CA16 ; v1(126.55,56.95) UC1.BW18 v1(126.55,57.6) ; v1(127.39,58.25) UC1.BV16 ; v1(127.39,58.25) UC1.BU15 ; v1(127.39,58.25) UC1.BV15 ; UC1.BV16 v1(126.55,57.6) ; UC1.BV16 v1(127.4,57.61) ; v1(128.23,55.65) UC1.CA14 v1(129.06,55.66) ; v1(128.23,55.65) UC1.CB15 v1(127.37,55.63) UC1.CA16 ; v1(128.23,55.65) UC1.CB14 128.67,55.32 v1(129.06,55.66) ; UC1.BV15 128.13,57.67 v1(128.23,57.6) ; UC1.BV15 128.13,58.17 UC1.BU14 v1(129.06,58.9) ; UC1.BV15 v1(127.4,57.61) ; 124.87,56.95 UC1.BW19 ; 124.87,56.95 UC1.BW20 ; 124.87,56.95 UC1.BY20 ; UC1.BR20 124.45,59.85 124.88,59.52 124.9,59.52 UC1.BT19 ; v1(129.06,58.9) UC1.BU12 ; v1(129.06,58.9) UC1.BT12 129.08,59.56 ; v1(124.03,57.6) UC1.BV20 v1(124.87,57.6) ; v1(124.03,57.6) UC1.BV22 ; v1(124.03,57.6) 124.24,57.43 UC1.BW20 ; UC1.CA16 v1(126.55,55.65) UC1.CA18 v1(125.72,55.64) UC1.CA19 v1(124.87,55.65) UC1.CA20 124.44,55.99 v1(124.05,56.3) 124.44,56.6 UC1.BY20 ; v1(125.73,59.56) UC1.BT19 ; UC1.BT19 v1(125.71,58.9) ; UC1.BT19 v1(124.88,58.9) UC1.BU19 ; UC1.BU22 v1(124.03,58.9) UC1.BT22 ; v1(129.06,55.66) UC1.CB12 UC1.CC12 ; v1(129.06,55.66) UC1.CA12 ; v1(126.55,57.6) UC1.BV18 125.69,58.23 v1(125.68,58.27) ; UC1.BR14 v1(128.23,59.55) 128.13,59.62 UC1.BR15 ; UC1.BR14 129.07,60.2 ; UC1.BR14 128.23,60.2 ; UC1.BR14 129.08,59.56 ; UC1.BU19 v1(125.71,58.9) ; UC1.BU19 v1(125.68,58.27) ; v1(125.71,58.9) UC1.BT18 ; v1(125.71,58.9) UC1.BU18 ; UC1.BW20 v1(124.87,57.6) ; UC1.BT18 v1(126.55,59.55) ; UC1.BT18 v1(126.55,58.9) UC1.BU18 ; 128.23,60.2 UC1.BP14 129.07,60.2 ; 128.23,60.2 UC1.BR15 ; v1(125.68,58.27) UC1.BV19 v1(124.87,57.6) ; v1(125.68,58.27) UC1.BU18 ; UC1.BP20 UC1.BP22 ; 129.07,60.2 UC1.BR12 129.08,59.56 ; UC1.BR15 v1(127.37,59.53)
  BOTTOM w0.254: UC1.BR20 UC1.BP20
  BOTTOM w0.508: RC130.1 146.53,41.71 v1(148.75,43.94) ; v1(145.89,84.26) 145.07,84.26 143.27,82.46 RC153.1
  vias: v1(121.13,109.47) v1(121.13,108.83) v1(121.7,109.02) v1(121.7,108.39) v1(128.75,104.9) v1(148.56,48.06) v1(148.56,47.43) v1(148.56,46.79) v1(148.56,46.16) v1(148.56,45.52) v1(148.56,44.89) v1(149.2,48.06) v1(149.2,47.43) v1(149.2,46.79) v1(149.2,46.16) v1(149.2,45.52) v1(149.2,44.89)
+1.05V_VCCDSW: length 1.6
  TOP w0.381: v1(121.48,58.93) 121.4,58.84 CC59.1
  BOTTOM w0.254: UC1.BT24 121.63,58.93 v1(121.48,58.93)
+1.05V_XTAL: length 16.9
  TOP w0.112: CC56.1 133.21,45.64 133.49,45.36 v3(133.49,45.08)
  TOP w0.356: v1(134.32,46.65) 134.09,46.41 CC56.1
  TOP w0.508: CC57.1 133.7,47.55 134.32,46.93 v1(134.32,46.65)
  BOTTOM w0.254: v1(134.32,46.65) 134.32,47.13 134.02,47.43 134.02,48.05 UC1.CP5
  BOTTOM w0.508: RC130.2 141.13,41.71 139.06,43.79 136.14,43.79 135.23,44.7 135.18,44.7 134.33,45.55 134.33,46.63 v1(134.32,46.65)
+1.05VALWP: length 29.6
  IN1 w0.254: v1(151.29,48.89) 150.4,48.89 150.15,48.64 150.15,48.24 149.89,47.99 149.89,42.22 151.48,40.64 159.68,40.64 161.08,42.05 163.58,42.05 166.8,45.27 v1(167.17,45.27)
  BOTTOM w0.254: PRH08.2 165.77,44.83 166.16,45.22 PCH14.1 v1(167.17,45.27)
  vias: v1(151.29,48.26) v1(151.29,47.62) v1(151.93,48.89) v1(151.93,48.26) v1(151.93,47.62) v1(152.05,49.65) v1(152.56,48.89) v1(152.56,48.26) v1(152.56,47.62) v1(152.69,49.65) v1(153.2,48.89) v1(153.2,48.26) v1(153.2,47.62) v3(153.09,46.43)
+1.8V_AVDD: length 28.3
  TOP w0.127: RA2.2 39.61,22.31 39.24,22.68 v2(39.24,23.13)
  TOP w0.381: RA2.2 39.61,21.45 v1(39.79,21.27)
  IN2 w0.381: v1(39.79,21.27) 39.84,21.21 39.84,21 39.84,6.22 39.46,5.84 35.34,5.84 33.44,7.74 29.82,7.74 v1(29.69,7.87)
+1.8V_CPVDD: length 18.2
  TOP w0.381: RA5.2 v2(36.05,22.03) 35.53,22.03 v1(35.51,22.05)
  IN1 w0.381: v1(26.89,11.3) 28.86,13.27 28.86,14.73 29.24,15.11 33.24,15.11 33.75,15.62 33.75,19.17 35.51,20.93 v1(35.51,22.05)
+1.8V_PRIM: length 388.3
  TOP w0.254: 125.03,53.93 124.37,53.27 124.37,52.13 124.09,51.85 123.5,51.85 RC202.1
  TOP w0.356: v1(126.42,47.55) 126.04,47.94 CC64.1
  TOP w0.508: v1(25.88,127.19) 25.13,126.44 RT13.1 ; v1(20.61,118.18) 20.99,118.56 RT16.1 ; v1(124.24,43.03) 124.63,43.42 RC53.1 ; RC121.1 RC122.1 RC162.1 122.72,43.52 122.52,43.33 v1(122.52,43.19) ; RT15.1 RT12.1 24.82,117.61 24.62,117.81 v1(24.62,118.27)
  TOP w1.016: 44.55,115.31 40.74,119.12
  IN1 w0.508: v1(25.88,127.19) 25.69,127 25.69,118.78 25.18,118.27 v1(24.62,118.27) ; v1(20.61,118.18) 20.61,125.09 v1(19.59,126.11)
  IN1 w1.016: 53.63,48.19 52.7,49.12 48.21,49.12 47.02,47.94 44.74,47.94 41.44,51.24 37.88,51.24
  IN2 w0.508: 53.97,61.06 53.12,61.91 53.12,65.08 51.02,67.18 51.02,79.05 51.79,79.81 52.99,79.81 54.67,78.14 v1(54.67,77.5)
  IN2 w1.016: 90.14,45.59 90.08,45.59 89.26,44.76 87.76,44.76 86.15,43.16 81.73,43.16 81.05,42.48 79.88,42.48 78.06,40.66 69.54,40.66 68.58,41.62 65.6,41.62 64.88,40.91 61.24,40.91 59.3,42.85 57.11,42.85 56.09,43.86 56.09,46.99 ; 112.18,114.42 122.53,114.42 123.98,112.97 129.31,112.97 132.11,110.17 135.92,110.17 139.34,106.75 159.07,106.75 170.67,95.14 170.67,75.99 173.75,72.91 180.98,72.91 182.59,71.3 182.59,70.45 188.78,64.26 189.58,64.26 191.68,62.16 ; 53.97,61.06 53.97,49.11
  IN2 w2.032: 182.85,49.08 188.69,54.92 188.69,57.02 189.9,58.22
  IN3 w0.508: v1(124.24,43.03) 124.24,43.17 123.73,43.67 123.01,43.67 v1(122.52,43.19)
  IN3 w1.016: 38.9,120.9 32.1,127.69 28.55,127.69 ; 31.4,22.66 30.77,23.3 22.39,23.3 21.32,24.37 21.32,27.44 21.69,27.81 21.69,29.33 23.91,31.55 25.47,31.55 28.2,34.29 30.66,34.29 30.91,34.53 32.57,34.53 35.09,37.05 35.09,39.56 36.1,40.57
  BOTTOM w0.152: v1(126.42,47.55) 126.49,47.62 126.49,48.2 126.49,48.22 UC1.CP17
  BOTTOM w0.203: v1(127.39,54.35) UC1.CD16 ; v1(127.39,54.35) UC1.CD15 v1(127.39,53.7) UC1.CD16 ; v1(127.39,54.35) UC1.CC15 ; UC1.CD16 v1(126.51,53.69) UC1.CD18 v1(125.71,53.7) UC1.CD19 ; UC1.CP23 122.71,48.19 122.66,48.14 122.66,47.44 v1(122.71,47.39) ; v1(125.71,54.35) UC1.CC19
  BOTTOM w0.508: R26.1 27.09,128.96 v1(26.83,128.71) ; RC200.1 125,43.67 124.62,43.29 124.5,43.29 v1(124.24,43.03) ; v1(122.52,43.19) 122.58,43.14 122.58,42.57 RC52.1
  BOTTOM w1.016: 46.26,115.25 49.31,118.3 54.01,118.3 57.78,114.52 101.81,114.52 104.64,111.69 111.67,111.69
  vias: v1(31.66,21.65) v1(32.3,21.63) v1(36.48,41.84) v1(36.8,51.62) v1(36.8,50.99) v1(37.12,41.84) v1(39.66,120.2) v1(40.1,119.76) v1(44.8,114.36) v1(45.44,114.36) v1(54.9,48.32) v1(55.41,47.81) v1(111.54,113.15) v1(112.18,113.15) v1(192.12,61.34) v1(192.12,60.7) v1(192.76,61.27) v1(192.76,60.64) v3(19.15,125.26)
