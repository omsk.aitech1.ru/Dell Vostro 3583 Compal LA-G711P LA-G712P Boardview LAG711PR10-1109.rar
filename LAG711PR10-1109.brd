# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_CORE_GT: length 33.9
  BOTTOM w0.102: UC1.AH9 131.64,76.51 ; UC1.AH9 131.25,76.12 ; UC1.AH9 131.64,76.11 ; UC1.AH9 131.23,76.52 ; UC1.AK9 131.64,75.58 ; UC1.AK9 131.65,75.18 ; UC1.AK9 131.25,75.58 ; UC1.AK9 131.23,75.18 ; UC1.AD9 131.64,79.28 ; UC1.AD9 131.26,78.9 ; UC1.AD9 131.23,79.29 ; UC1.AD9 131.64,78.88 ; 131.68,81.17 UC1.Y8 ; UC1.Y8 131.96,81.45 132.23,81.45 ; UC1.Y8 131.77,81.53 131.57,81.53 ; UC1.AJ10 131.18,75.66 ; UC1.AJ10 131.18,76.05 ; UC1.AJ10 130.78,76.05 v1(130.78,76.31) ; UC1.AJ10 130.78,75.65 v1(130.78,75.39) 130.78,75.13 UC1.AL10 ; UC1.AB10 130.73,80.73 v1(130.73,80.94) ; UC1.AB10 131.18,80.66 ; UC1.AB10 131.18,80.27 ; UC1.AB10 130.73,80.21 130.73,80.07 v1(130.69,80.03) ; 131.18,81.2 UC1.Y10 131.12,81.53 131.36,81.53 ; 131.24,77.03 UC1.AG9 ; UC1.AG9 131.64,77.44 ; UC1.AG9 131.64,77.04 ; UC1.AG9 131.24,77.44 ; UC1.AB8 132.15,80.22 v1(132.15,80.01) 132.15,79.79 UC1.AC8 ; UC1.AB8 132.15,80.72 v1(132.15,80.92) ; UC1.AB8 131.71,80.66 ; UC1.AB8 131.71,80.28 ; UC1.AL10 131.18,75.13 ; UC1.AL10 130.78,74.72 ; UC1.AL10 131.18,74.73 ; UC1.AE9 131.23,77.95 ; UC1.AE9 131.23,78.37 ; UC1.AE9 131.64,78.36 ; UC1.AE9 131.63,77.97 ; UC1.AJ8 131.72,76.03 ; UC1.AJ8 132.15,76.1 v1(132.15,76.3) 132.15,76.53 UC1.AG8 ; UC1.AJ8 131.71,75.66 ; UC1.AJ8 132.15,75.6 v1(132.15,75.37) 132.15,75.17 UC1.AL8 ; UC1.AA9 131.63,80.74 ; UC1.AA9 131.63,81.12 ; UC1.AA9 131.25,81.12 ; UC1.AA9 131.25,80.74 ; UC1.AL9 131.24,74.67 ; UC1.AL9 131.64,74.66 ; UC1.AL9 131.24,74.26 ; UC1.AL9 131.64,74.26 ; 131.69,73.8 UC1.AM8 ; UC1.AM8 132.15,73.75 132.15,73.54 ; UC1.AM8 131.97,74.07 132.19,74.07 ; UC1.AM8 131.69,74.21 ; UC1.AL8 131.97,74.86 132.19,74.86 ; UC1.AL8 131.69,74.72 ; UC1.AL8 131.7,75.13 ; UC1.AE10 130.77,78.4 ; UC1.AE10 130.78,78.83 ; UC1.AE10 131.17,78.81 ; UC1.AE10 131.18,78.42 ; UC1.AB9 131.23,79.8 ; UC1.AB9 131.24,80.21 ; UC1.AB9 131.64,79.81 ; UC1.AB9 131.64,80.21 ; UC1.AF8 132.15,77.45 v1(132.15,77.23) 132.15,77.02 UC1.AG8 ; UC1.AF8 131.69,77.49 ; UC1.AF8 131.7,77.89 ; UC1.AF8 132.15,77.95 v1(132.15,78.16) 132.15,78.37 UC1.AE8 ; UC1.AE8 132.16,78.88 v1(132.16,79.12) 131.9,79.38 UC1.AC8 ; UC1.AE8 131.72,78.8 ; UC1.AE8 131.71,78.43 ; 131.72,76.59 UC1.AG8 ; UC1.AG8 131.69,76.98 ; UC1.AF10 131.18,77.89 ; UC1.AF10 130.75,77.47 ; UC1.AF10 130.79,77.89 ; UC1.AF10 131.17,77.51 ; UC1.AC8 131.7,79.75 ; UC1.AC8 131.7,79.34
  BOTTOM w0.18: UC1.AK2 136.61,75.19 136.79,75.37 v1(137.08,75.37) ; UC1.AB2 136.93,80.07 v1(136.99,80.12)
  BOTTOM w0.203: v1(136.94,82.62) 136.83,82.51 UC1.V2
  BOTTOM w0.254: v1(136.79,77.79) 136.39,77.79 UC1.AF2
  vias: v1(125.37,80.13) v1(126.01,80.13) v1(126.59,80.13) v1(126.91,80.75) v1(127.17,80.13) v1(127.49,80.75) v1(130.35,77.7) v1(130.72,79.08) v3(136.01,76.78)
+VCC_GT: length 52.7
  BOTTOM w0.102: 130.78,87.14 130.78,87.14 UC1.L10 ; 131.74,81.81 131.49,81.81 UC1.W9 ; 131.7,83.96 UC1.T8 ; UC1.T8 132.15,84.41 v1(132.15,84.63) 132.15,84.84 UC1.P8 ; UC1.T8 131.69,84.37 ; UC1.T8 132.15,83.92 v1(132.15,83.7) 132.15,83.49 UC1.U8 ; UC1.W9 131.39,81.81 131.14,81.81 ; UC1.W9 131.65,82.07 ; UC1.W9 131.23,82.06 ; 131.26,83.89 UC1.T9 ; UC1.T9 131.64,83.9 ; UC1.T9 131.64,83.51 ; UC1.T9 131.25,83.51 ; UC1.U10 130.78,83.44 v1(130.78,83.7) 130.78,83.96 UC1.T10 ; UC1.U10 131.18,83.44 ; UC1.U10 130.8,83.06 v1(130.8,82.77) ; UC1.U10 131.17,83.05 ; 131.71,82.13 131.71,82.13 UC1.W8 ; UC1.U8 132.15,82.99 v1(132.15,82.78) 132.15,82.56 UC1.W8 ; UC1.U8 131.71,83.43 ; UC1.U8 131.69,83.03 ; UC1.P8 132.15,85.34 v1(132.15,85.55) 132.15,85.76 UC1.N8 ; UC1.P8 131.7,85.29 ; UC1.P8 131.69,84.88 ; UC1.L8 132.12,87.16 132.12,87.16 ; UC1.L8 132.15,86.69 v1(132.15,86.47) 132.15,86.26 UC1.N8 ; UC1.L8 131.69,87.14 131.69,87.14 ; UC1.L8 131.72,86.75 ; 131.63,85.74 UC1.N9 ; UC1.N9 131.23,85.34 ; UC1.N9 131.25,85.74 ; UC1.N9 131.63,85.36 ; 131.64,82.58 UC1.V9 ; UC1.V9 131.25,82.97 ; UC1.V9 131.64,82.97 ; UC1.V9 131.23,82.57 131.23,82.57 ; UC1.W8 132.15,82.07 v1(132.15,81.85) ; UC1.W8 131.7,82.52 ; UC1.N8 131.71,85.82 ; UC1.N8 131.69,86.22 ; 131.21,87.16 131.21,87.16 UC1.L10 ; UC1.N10 131.18,85.82 ; UC1.N10 130.78,85.81 v1(130.78,85.55) ; UC1.N10 131.18,86.21 ; UC1.N10 130.78,86.21 v1(130.78,86.47) 130.78,86.73 UC1.L10 ; 131.64,84.42 131.64,84.43 UC1.R9 ; UC1.R9 131.24,84.83 131.23,84.83 ; UC1.R9 131.64,84.83 ; UC1.R9 131.24,84.42 ; 131.23,86.68 UC1.M9 ; UC1.M9 131.64,86.28 ; UC1.M9 131.64,86.67 ; UC1.M9 131.26,86.29 ; v1(130.78,84.63) 130.78,84.37 UC1.T10 ; UC1.L10 131.18,86.74 ; UC1.T10 131.18,83.96 ; UC1.T10 131.18,84.36
  BOTTOM w0.18: v1(137.66,88.32) 137.54,88.2 137.48,88.2 136.8,87.52 136.35,87.52 UC1.K2 ; UC1.P2 137.24,84.95 137.76,85.47 v1(137.96,85.47)
  BOTTOM w0.203: v1(132.78,85.55) UC1.N7 v1(132.78,86.47) UC1.L7 v1(132.78,87.4) UC1.J7 v1(132.8,88.33) UC1.H7 v1(132.78,89.24) UC1.F7 ; UC1.F5 v1(134.07,89.24) ; UC1.F5 v1(134.05,90.18) ; UC1.F5 UC1.F6 ; UC1.J8 v1(132.17,88.33) UC1.H8 v1(132.15,89.24) UC1.F8 UC1.F7 ; UC1.F6 v1(133.42,89.24) UC1.H6 v1(133.44,88.33) ; UC1.F6 v1(133.42,90.17) ; UC1.F6 v1(132.78,90.17) ; v1(132.15,93.67) UC1.A8 UC1.B8 ; UC1.E4 UC1.D4 UC1.C3 ; 133.85,88.78 UC1.H5 v1(134.08,88.32) ; UC1.B8 UC1.C7 UC1.B6 ; UC1.B8 UC1.C8 UC1.D7 ; UC1.D7 v1(132.78,90.17) ; UC1.D7 UC1.C6 UC1.B6 ; UC1.C3 UC1.B3 UC1.B4 UC1.A5 ; UC1.C3 UC1.C2 ; UC1.F7 v1(132.78,90.17) ; UC1.B6 UC1.A6
  BOTTOM w0.508: RC169.1 139.86,96.96 v1(140.05,97.15)
  vias: v1(122.14,85.97) v1(122.14,85.34) v1(122.14,84.7) v1(122.14,84.01) v1(124.3,85.85) v1(125.37,92.95) v1(125.37,91.65) v1(125.37,91) v1(125.37,89.7) v1(125.37,89.05) v1(125.37,87.75) v1(125.38,85.85) v1(127.08,86.3) v1(127.26,92.95) v1(127.26,92.3) v1(127.26,91.65) v1(127.26,91) v1(127.26,89.7) v1(127.26,89.05) v1(127.26,88.4) v1(127.26,87.75) v1(128.2,92.95) v1(128.2,91.65) v1(128.2,91) v1(128.2,90.35) v1(128.2,89.7) v1(128.2,89.05) v1(128.2,87.75) v1(128.27,86.29) v1(130.13,87.7) v1(130.18,87.1) v1(130.2,86.52) v1(130.33,85.92) v1(130.35,84.16) v1(130.37,83.24) v1(130.75,81.86) v1(130.97,94.04) v1(132.74,93.66) v1(133.25,93.08) v1(148.05,103.06) v1(148.05,102.36) v1(148.05,101.72) v1(148.05,101.09) v1(149.2,98.86) v1(149.23,98.21) v1(149.23,97.58) v1(149.23,96.94) v1(149.83,98.86) v1(149.79,96.36) v1(149.79,95.72) v1(149.86,98.21) v1(149.86,97.58) v1(149.86,96.94) v1(150.37,96.36) v1(150.37,95.72) v1(150.37,95.09) v1(150.5,98.85) v1(150.5,98.21) v1(150.5,97.58) v1(150.5,96.94) v1(151,96.36) v1(151,95.72) v1(151,95.09) v1(151,94.5) v1(151.23,102.99) v1(151.23,102.36) v1(151.23,101.72) v1(151.23,101.09) v1(151.64,96.36) v1(151.64,95.72) v1(151.64,95.09) v1(151.64,94.5) v1(151.86,102.36) v1(151.86,101.72) v1(151.86,101.09) v3(146.64,89.16)
+VCC_SA: length 30.1
  TOP w0.508: RC164.1 144,65.38 143.84,65.38 143.04,66.18 141.4,66.18 139.98,64.75 139.05,64.75 138.73,64.44 137.1,64.44 136.06,63.4 135.1,63.4
  BOTTOM w0.076: UC1.BK8 132.2,62.62 v1(132.2,62.53) 132.2,62.29 132.15,62.24
  BOTTOM w0.102: UC1.BG8 132.15,64.52 v1(132.15,64.3) 132.15,64.09 UC1.BJ8 ; UC1.BG8 131.97,64.84 132.25,64.84 ; UC1.BG8 131.77,64.89 131.59,64.89 ; UC1.BG8 131.69,64.56 ; UC1.BL8 132.15,62.24 ; UC1.BL8 131.7,62.2 ; UC1.BL8 131.8,61.89 131.54,61.89 ; UC1.BJ9 131.63,63.57 ; UC1.BJ9 131.66,63.16 ; UC1.BJ9 131.25,63.57 ; UC1.BJ9 131.23,63.17 ; UC1.BJ8 131.72,64.02 ; UC1.BJ8 132.15,63.59 v1(132.15,63.38) 132.15,63.16 UC1.BK8 ; UC1.BJ8 131.7,63.64 ; UC1.BG10 130.78,64.56 v1(130.78,64.3) 130.78,64.04 UC1.BJ10 ; UC1.BG10 130.91,64.84 130.7,64.84 ; UC1.BG10 131.11,64.89 131.34,64.89 ; UC1.BG10 131.18,64.56 ; 120.74,63.11 120.99,63.11 UC1.BK25 ; UC1.BK8 131.72,62.73 ; UC1.BK8 131.7,63.11 ; UC1.BH9 131.64,64.1 ; UC1.BH9 131.24,64.1 ; UC1.BH9 131.24,64.51 ; UC1.BH9 131.64,64.5 ; UC1.BL9 131.64,62.25 ; UC1.BL9 131.67,62.68 ; UC1.BL9 131.22,62.68 ; UC1.BL9 131.23,62.25 ; UC1.BJ10 131.18,63.64 ; UC1.BJ10 131.18,64.04 ; UC1.BJ10 130.78,63.64 v1(130.78,63.38) ; UC1.BK25 121.18,63.11 121.43,63.11 ; UC1.BK25 121.3,62.81 ; UC1.BK25 120.91,62.83 ; 131.19,62.2 UC1.BL10 130.75,61.76 ; UC1.BN25 121.33,60.95 ; UC1.BN25 120.87,61.41 ; UC1.BN25 121.28,61.38 ; 121.36,62.76 UC1.BL24 121.44,62.45 121.15,62.45 ; 121.36,61.46 UC1.BM24 ; UC1.BM24 121.44,61.76 121.25,61.76 ; UC1.BM24 121.76,61.44 ; 120.41,62.77 UC1.BL26 ; UC1.BL26 120.82,62.76 ; UC1.BL26 120.84,62.35 ; UC1.BL26 120.42,62.35 ; 120.26,62.73 120.16,62.83 UC1.BK27 120.26,63.11 120.52,63.11
  vias: v1(121.95,62.86) v1(122.46,62.16) v1(122.59,62.8) v1(125.39,64.88) v1(125.38,62.43) v1(126.66,64.88) v1(126.65,62.43) v1(127.93,64.88) v1(127.93,62.4) v1(129.13,62.42) v1(129.2,64.88) v1(130.35,64.76) v1(152.37,56.38) v1(152.37,55.75) v1(152.37,55.11) v1(152.37,54.48) v1(153.01,55.75) v1(153.01,55.11) v1(153.01,54.48) v1(153.01,53.84) v1(153.01,53.21) v1(153.64,55.75) v3(151.81,56.07)
+VCCIO: length 28.9
  TOP w0.254: RC4.1 131.85,74.76 v1(132.15,74.46)
  TOP w0.432: v1(126.55,60.2) 126.96,60.61 CC25.1
  IN3 w0.508: v1(122.22,74.41) 122.41,74.61 132,74.61 v1(132.15,74.46)
  BOTTOM w0.102: 120.83,74.61 UC1.AL26 ; UC1.AL26 120.41,74.19 ; UC1.AL26 120.82,74.21 ; UC1.AL26 120.4,74.63 ; v1(121.77,73.95) 121.77,74.19 UC1.AL24 ; 121,75.38 120.69,75.38 UC1.AK26 ; UC1.AK24 121.49,75.38 121.2,75.38 ; UC1.AK24 121.77,75.1 v1(121.77,74.86) 121.77,74.62 UC1.AL24 ; UC1.AK24 121.6,75.37 121.88,75.37 ; UC1.AK24 121.37,75.13 ; UC1.AL24 121.36,74.21 ; UC1.AL24 121.37,74.59 ; 120.74,73.86 120.99,73.86 UC1.AM25 ; 120.26,63.39 120.54,63.39 UC1.BJ26 ; 121.29,75.07 UC1.AL25 ; UC1.AL25 120.89,74.66 ; UC1.AL25 121.29,74.67 ; UC1.AL25 120.88,75.07 ; UC1.BH27 119.87,64.22 v1(119.87,64.38) ; UC1.BH27 120.36,63.73 ; UC1.BH27 119.87,63.64 v1(119.87,63.47) ; UC1.BH27 120.36,64.13 ; UC1.AK26 120.57,75.38 120.25,75.38 ; UC1.AK26 120.83,75.11 ; UC1.AK26 120.4,75.09 ; 121,64.51 120.75,64.51 UC1.BH26 ; UC1.BH25 UC1.BH26 ; UC1.BH25 UC1.BJ26 ; UC1.BH25 UC1.BJ24 ; UC1.BH25 UC1.BH24 ; UC1.BH26 120.42,64.18 ; UC1.BH26 120.5,64.51 120.29,64.51 ; UC1.AM25 121.18,73.86 121.47,73.86 ; UC1.AM25 120.9,74.14 ; UC1.AM25 121.29,74.15 ; UC1.BJ24 121.63,63.39 121.91,63.39 ; UC1.BJ24 121.47,63.39 121.18,63.39 ; 120.43,63.67 UC1.BJ26 ; UC1.BJ26 120.71,63.39 120.97,63.39 ; UC1.BH24 121.43,64.51 121.2,64.51 ; UC1.BH24 121.6,64.43 121.86,64.43
  BOTTOM w0.254: UC1.BP18 v1(126.55,60.2) UC1.BP16
  vias: v1(119.87,74.41) v1(119.87,73.5) v1(121.89,63.92) v1(122.34,64.32) v1(122.53,63.75) v1(136.39,45.36) v1(136.39,44.78) v1(136.98,45.95) v1(136.98,45.36) v1(136.98,44.78) v1(137.56,45.39) v1(137.56,44.8) v1(144.86,45.09) v1(144.86,44.51) v1(145.41,44.8) v3(144.7,42.93)
+VCCIO_OUT: length 0.8
  TOP w0.112: v3(148.43,37.3) 148.43,38.06
+VCCLDOSRAM_1P24: length 3.8
  TOP w0.127: RC133.1 v2(123.38,55.68)
  TOP w0.508: v1(122.34,56.33) 122.34,56.32 RC133.1
  BOTTOM w0.203: v1(122.34,56.33) UC1.BY24 ; v1(122.34,56.33) UC1.BY23 ; v1(122.34,56.33) UC1.CA24 ; v1(122.34,56.33) UC1.CA23
+VCCPLL_OC: length 7.2
  TOP w0.508: 104.75,62.67 104.59,62.82 v3(102.55,62.82) 100.47,62.82 CZ40.1 RZ12.2
  BOTTOM w0.203: UC1.BM26 120.62,61.65 UC1.BL27 119.87,62.4 v1(119.87,62.56)
+VCCST: length 138.4
  TOP w0.508: v1(122.88,108.94) 124.49,110.55 v1(127.59,110.55) ; v1(175.9,60.33) 175.68,60.56 PRZ43.1 PRZ42.1 PRZ41.1 PRZ40.1 PCZ24.1 ; v1(149.56,62.78) v3(148.46,62.78) 148.03,62.78 147.25,63.56 CC72.1 144.03,63.56 142.8,64.79 v1(142.8,64.8) 142.8,64.98 142.31,65.46 141.55,65.46 139.96,63.88 139.61,63.88
  IN1 w0.508: v1(148.49,69.13) 147.75,69.13 142.27,74.61 142.27,79.81 142.46,80 142.46,80.07 ; 142.46,80.07 142.46,80.13 142.27,80.32 142.27,87.67 142.81,88.21 142.81,93.9 142.21,94.5 142.21,103.77 138.93,107.05 133.59,107.05 130.1,110.55 v1(127.59,110.55) ; 142.46,80.07 v1(142.91,80.07)
  IN2 w0.508: v1(174.85,64.26) 174.56,63.97 174.56,61.68 v1(175.9,60.33)
  IN3 w0.508: v1(149.56,62.78) 149.56,59.96 150.48,59.04 159.24,59.04 161.02,60.81 161.02,65.58 162.1,66.67 165.26,66.67 167.88,64.05 174.65,64.05 v1(174.85,64.26)
  BOTTOM w0.18: v1(137.13,60.53) 137.11,60.54 UC1.BP2
  BOTTOM w0.203: UC1.BT11 130.4,59.21 v1(130.88,59.54) 130.35,59.79 UC1.BR11
  BOTTOM w0.254: v1(130.87,60.6) 130.79,60.52 UC1.BP11
  BOTTOM w0.508: RC2.1 139.76,63.99 RC145.1 140.5,63.99 142.29,63.99 142.8,64.5 v1(142.8,64.8) 147.14,69.13 v1(148.49,69.13) ; RC134.1 143.29,78.54 143.73,78.99 143.73,79.58 143.25,80.07 v1(142.91,80.07) 141.19,80.07 140.81,80.45 RC3.1 RC136.1
+VCCST_OUT:
  vias: v2(125.9,110.28)
+VCCSTG: length 88.6
  TOP w0.508: v1(121.83,104.71) 129.64,96.9 134.5,96.9 137.03,94.37 139.62,94.37 141.19,95.94 141.19,96.96 144.15,99.91 v1(144.15,100.45) ; RC150.1 RC151.1 v1(145.89,83.43) 145.96,83.5 146.7,83.5 147.21,82.99 v3(147.21,82.64) 147.21,82.27 146.85,81.91 RC152.1 ; v1(142.91,81.34) 141.13,81.34 139.29,79.5 139.29,76.06 137.84,74.61 134.58,74.61 134.45,74.48 v1(133.51,74.48)
  IN1 w0.508: v1(145.89,83.43) 146,83.43 146.5,83.94 146.5,85.18 144.66,87.02 144.66,98.81 144.15,99.31 v1(144.15,100.45) ; v1(133.51,74.48) 135.04,74.48 136.05,73.46 136.05,67.81 137.58,66.29 v1(137.58,66.16)
  BOTTOM w0.203: UC1.BG3 UC1.BG2 UC1.BG1 136.98,65.2 137.18,65.2 137.58,65.59 v1(137.58,66.16)
  BOTTOM w0.254: CC19.1 138.17,66.1 138.11,66.16 v1(137.58,66.16)
  BOTTOM w0.508: v1(145.89,83.43) 145.11,83.43 143.02,81.34 v1(142.91,81.34) RC1.1
+VCCSTG_OUT: length 1
  BOTTOM w0.112: CZ8.1 v2(125.81,103.3)
+VDD_CT: length 5.8
  TOP w0.102: v2(120.38,136.58) 120.08,136.28 v1(119.86,136.28)
  TOP w0.508: RV7.2 v1(112.56,137.08)
  BOTTOM w0.381: v1(118.56,137.02) 119.12,137.02 UV1.AB21 v1(119.86,136.28) ; v1(119.86,136.28) 119.38,135.8 UV1.AB20 ; v1(119.86,136.28) UV1.AA20 ; v1(119.86,136.28) 120.14,136.57 120.34,136.76 UV1.AA21
+VDDR3: length 19
  TOP w0.102: v1(119.85,133.41) 120.05,133.61 v2(120.46,133.61)
  BOTTOM w0.254: 111.46,135.26 112.24,135.26 112.53,134.98 115.5,134.98 115.77,134.7 115.77,134.49 ; 115.77,134.49 115.5,134.22 112.97,134.22 112.65,133.9 112.11,133.9 112.07,133.94 ; 115.77,134.49 116.14,134.49
  BOTTOM w0.381: 116.14,134.49 116.61,134.49 116.65,134.53 118.29,134.53 v1(118.4,134.64) 119.18,134.64 UV1.AB18 UV1.AA18 UV1.AA17 119.95,133.41 v1(119.85,133.41) 119.46,133.8 UV1.AB17
  BOTTOM w0.508: RV10.2 110.66,135.26 111.46,135.26 111.46,134.32 111.84,133.94 112.07,133.94
GND: length 2739
  TOP w0.203: UE1.100 37.06,80.61 v1(38.16,81.7) ; v1(50.07,76.64) 50.11,76.61 UE1.51 ; UE1.124 36.87,71.01 v1(37.07,71.21) ; UZ3.11 40.45,58.03 v1(40.6,57.88) ; v1(50.03,81.64) 50.2,81.81 UE1.64 ; v1(125.71,55) 125.67,54.96 CC61.2 ; v1(37.98,31.19) 37.65,30.85 PUM01.1 ; PUM01.3 v1(36.85,31.31) ; UE1.84 v1(42.15,84.83) ; UE1.17 43.75,69.47 44.58,70.3 v1(44.61,70.3)
  TOP w0.229: PCI138.2 131.13,80.48 130.36,80.48 v1(130.34,80.5)
  TOP w0.254: PCI137.2 130.37,79.56 v1(130.35,79.54) ; 126.65,129.47 v1(126.65,129.47) ; v1(129.05,47.68) 129.19,47.68 129.96,48.45 RC72.2 ; v1(114.78,137.22) RV12.2 115.25,136.16 CV29.2 ; CV32.1 61.83,124.09 62.53,124.79 UV3.3 ; v1(8.37,123.78) 8.12,123.78 8.08,123.82 8,123.82 ; 131.16,78.62 v1(130.35,78.62) ; v1(126.55,58.25) 125.93,57.63 CC55.2 ; v1(120.54,59.95) 120.54,60.12 120.68,60.26 ; CV30.2 RV14.2 113.76,134.83 113.3,135.29 112.97,135.29 v1(112.74,135.53) ; PCI139.2 131.15,81.4 130.36,81.4 v1(130.35,81.42)
  TOP w0.279: v1(7.91,117.79) 7.91,118.04 7.63,118.32 JUSBC1.A12 ; JUSBC1.A1 7.35,123.82 8,123.82
  TOP w0.305: JVGA1.10 218.21,34.25 218.56,34.6 v1(218.56,34.79) ; v1(148.62,41.66) 149.12,41.17 UZ2.5 ; JVGA1.1 v1(218.77,38.75) ; JVGA1.4 v1(218.71,37.25) ; JDEG1.10 39.25,98.13 v1(39.21,98.17) ; UZ7.5 v1(98.59,60.17)
  TOP w0.356: CD13.2 77.75,47.56 v1(77.72,47.52) ; CC43.2 115.91,73.76 v1(115.59,74.08) ; PCM14.2 31.66,23.88 v1(31.78,23.76) ; CD8.2 81.73,67.09 v1(82.08,66.74) ; CZ10.2 CZ9.2 154.47,39.11 154.91,38.67 v1(155.8,38.67) ; v1(56.9,64.11) 57.07,63.94 CD35.2 ; v1(109.89,112.9) 109.89,109.65 107.11,106.87 UC2.3 ; CC56.2 132.29,47.54 CC57.2 ; CD37.2 69.57,91.12 v1(69.63,91.17) ; v1(115.59,76.6) 115.78,76.79 CC44.2 ; v1(68.61,69.06) 68.53,69.15 CD10.2 ; CV154.2 156.21,135.73 v1(156.14,135.8) ; v1(67.85,63.77) 67.92,63.71 67.92,63.3 68.17,63.05 CD12.2 ; CV92.2 CV93.2 132.53,124.63 v1(132.51,124.66) ; CD15.2 75.45,58.22 v1(75.36,58.14) ; CD11.2 81.1,69.19 v1(81.22,69.06) ; v1(65.13,74.78) 65.17,74.73 CD40.2 ; v1(56.93,64.72) 56.3,65.36 RD20.2 ; CC42.2 116.43,84.99 v1(115.59,84.15) ; CC78.1 94.28,42.53 94.85,43.1 UC8.3 ; v1(151.91,130.29) 152.02,130.18 CV180.2 ; C16.2 v1(222.41,58.22) ; v1(35.98,24.48) 35.2,24.48 PCM13.2 ; CV159.2 159.97,135.71 v1(160.02,135.76) ; v1(118.22,133.43) 118.22,132.94 CV20.2 ; v1(65.01,47.49) 65.07,47.56 CD41.2 ; CV150.2 164.57,144.78 v1(164.88,145.09) ; CZ14.2 38.26,55.88 38.36,55.97 38.99,55.97 CZ18.2 ; CD42.2 65.41,58.46 v1(65.06,58.11) ; CC65.2 CC66.2 120.21,47.34 v1(120.19,47.32) ; v1(69.62,85.66) 69.54,85.57 CD36.2 ; CC41.2 116.03,69.49 v1(115.59,69.05) ; v1(74.13,115.61) 74.13,115.98 73.78,116.34 PC2504.2 ; v1(130.31,76.75) 130.5,76.93 PCI140.2 PCI134.2 PCI136.2 131.01,78.47 PCI135.2 ; CV177.2 157.9,130.58 v1(157.9,130.15) ; CD26.2 67.66,83.84 v1(67.98,84.16) ; CV85.2 130.2,123.59 CV84.2 ; CV181.2 v1(165.34,130.11) ; CD39.2 57.48,86.09 57.12,85.74 v1(57.02,85.74) ; v1(127.34,124.48) 127.59,124.73 CV83.2 128.32,124.28 RV41.1 ; v1(116.49,132.01) 116.09,131.61 CV26.2 ; CV156.2 158.19,135.62 v1(158.33,135.76) ; CV179.2 v1(165.49,125.79) ; CD9.2 81.1,91.26 v1(81.07,91.29) ; CC14.2 93.25,56.27 RC105.2 ; v1(154.34,130.23) 154.19,130.08 CV176.2 ; CV34.2 CV33.2 117.45,128.82 v1(117.32,128.69) ; v1(14.92,87.46) 15.36,87.02 15.36,86.67 ; CD14.2 72.33,52.73 v1(72.35,52.75) ; CV175.2 152.45,127.85 v1(152.31,127.71) ; v1(64.95,102.07) 64.96,102.09 CD38.2 ; v1(118.65,135.8) 118.91,135.54 CV65.2 ; C3.2 63.38,37.78 v1(63.2,37.96) ; RC172.2 116.49,91.04 v1(116.41,90.95) ; CV174.2 150.4,116.64 150.94,117.18 v1(150.94,117.33) ; CC64.2 v1(125.26,47.3) ; CZ13.2 v1(35.21,57.84)
  TOP w0.381: CL16.2 23.66,87.96 RL9.2 ; v1(127.86,142.32) 128.05,142.13 128.05,139.85 127.73,139.53 CV46.2 ; CV190.2 v1(165.63,120.71) ; v1(76.93,124.58) 76.5,124.58 PCV27.2 76.31,124.51 75.52,125.3 PCV34.2 ; v1(213.37,39.05) C37.2 212.97,38.03 U2.2 ; v1(98.51,52.07) 98.31,52.27 UC9.3 ; v1(207.28,50.95) 206.87,50.54 PQB33.3 ; RC20.2 115.82,61.81 v1(115.63,61.62) ; v1(117.95,45.88) 117.79,45.88 117.41,46.26 RC60.1 ; v1(118.22,133.43) 118.22,133.58 117.55,134.26 CV28.2 RV9.2 ; UC4.3 98.57,54.94 v1(99.06,54.45) ; CV183.2 v1(165.64,126.86) ; RD7.2 67.62,67.03 v1(67.85,66.8) ; v1(118.65,135.8) 118.65,136.27 CV64.2 ; C7.2 212.14,57.44 C8.2 211.66,56.83 v1(211.12,56.28) ; CE27.2 32.2,67.76 31.83,67.39 30.96,67.39 30.72,67.15 v1(30.72,67.01) ; CC60.2 123.45,59.77 v1(123.24,59.56) 122.73,59.56 CC52.2 122.03,59.14 CC63.2 ; CV191.2 v1(165.63,119.69) ; v1(164.88,137.86) 164.65,137.63 CV163.2 ; CV182.2 v1(165.64,124.7) ; R77.1 215.25,55 215.81,55.56 v1(215.93,55.56) ; v1(124.48,42.49) 124.61,42.62 125.3,42.62 125.64,42.96 RC56.2 ; CU16.2 206.18,35.57 v1(206.41,35.8) ; CV185.2 v1(165.64,129.02) ; CV169.2 v1(157.43,150.59) ; CV167.2 v1(160.3,150.6) ; CV188.2 v1(165.63,122.74) ; R72.2 212.09,33.1 C35.2 v1(212.75,32.34) ; CZ41.2 35.58,57.48 v1(35.21,57.84) ; CV168.2 v1(159.34,150.59) ; v1(218.35,45.21) 217.98,45.21 217.15,44.38 ED3.1 ; CV184.2 v1(165.64,127.94) ; v1(160.33,126.13) 160.52,125.94 CV171.2 160.36,125.24 RV49.2 ; CV189.2 v1(165.63,121.72)
  TOP w0.406: QS1.4 167.49,30.9 v1(167.19,31.21) ; v1(99.16,39.36) 99.12,39.36 98.6,38.84 UC6.3 ; v1(38.45,98.86) 38.25,99.07 JDEG1.12 ; QT1.4 v1(22.12,116.66) ; JDEG1.11 44.75,101.1 v1(44.93,101.28) ; EU3.3 v1(17.43,31.81) ; v1(15.53,117.66) 15.53,117.64 15.48,117.64 15.21,117.91 EU9.3 ; PQ12.1 v1(168.83,36.75) ; QT1.1 22.88,115.36 22.77,115.25 v1(22.68,115.25) ; v1(39.15,89.47) 38.65,89.47 38.37,89.2 UE2.3 ; EU8.3 v1(15.27,125.03)
  TOP w0.432: v1(117.52,50.08) 118.06,50.08 RC209.2 ; v1(211.18,45.9) 211.18,46.05 211.61,46.48 C36.2 ; v1(121.5,56.29) 121.4,56.39 CC59.2
  TOP w0.457: v1(32.52,32.85) 32.91,32.85 PRM11.2 ; RC64.2 126.86,49.39 v1(126.75,49.5) ; CA31.2 v1(25.7,3.54) ; RC16.2 121.26,55.42 v1(121.53,55.69) ; v1(129.31,128.69) 128.79,128.16 CV44.2 ; CD20.2 77.37,81.59 v1(77.32,81.64) ; CA29.2 v1(21.94,2.73) 21.29,2.73 CA30.2 ; EU1.3 18,58.53 v1(17.81,58.35) ; v1(130.45,122.05) 130.45,122.44 130.2,122.69 CV84.2 ; PCV32.2 68.3,124.56 v1(67.81,125.04)
  TOP w0.508: v1(76.42,110.3) 76.42,111.83 75.85,112.4 PC2503.2 ; v1(69.46,96.75) 69.5,96.71 CD17.2 ; RA18.2 24.04,21.47 v1(23.88,21.62) ; v1(42.01,91.75) 42.01,91.31 41.89,91.19 CE22.2 CE24.2 ; PC308.2 19.99,42.93 v1(19.89,43.04) 19.56,43.37 PC303.2 ; CC72.2 147.42,64.96 v1(148.02,64.35) ; CA25.2 v1(25.69,21.65) ; v1(125.32,75.75) 125.32,75.37 PCI104.2 ; CD25.2 70.14,65.57 v1(69.71,65.15) ; C18.2 211.61,41.76 209.93,41.76 v1(209.66,42.03) PCB14.2 ; PD1.1 57.88,132.33 v1(57.82,132.39) ; v1(48.03,62.28) 47.53,62.78 CE19.2 RE40.2 RE26.2 CE18.2 ; CS31.2 181.45,36.52 v1(181.45,36.69) ; v1(126.72,68.51) 126.72,68.13 PCI115.2 ; PC2501.2 73.62,114.79 74.13,115.3 v1(74.13,115.61) ; PRH04.2 166.02,42.79 v1(166.09,42.73) ; v1(105.89,48.57) 106.06,48.41 CC11.2 106.27,46.21 106.78,45.7 v1(106.78,45.25) 106.78,43.49 106.4,43.11 102.77,43.11 102.46,43.42 v1(102.46,44.32) 102.46,45.7 102.96,46.21 CC12.2 103.36,47.89 v1(103.6,48.13) ; CD16.2 64.7,72.19 v1(64.55,72.34) ; v1(20.23,53.4) 21.2,54.38 EU2.1 ; CE6.2 54.57,73.38 v1(55.03,73.38) ; CA18.2 v1(24.29,10.45) ; v1(86.29,40.39) 86.15,40.25 RX13.2 ; v1(88.36,40.38) 88.43,40.44 CC77.1 89.06,39.57 RX21.1 ; PRV27.2 76.39,122.91 v1(76.36,122.93) ; CT11.2 CT6.2 16.19,125.09 v1(15.92,124.82) ; CA11.2 27.78,9.96 v1(27.4,9.58) 26.89,9.58 CA10.1 ; v1(126.97,117.79) 127.35,117.79 127.99,118.42 RV19.2 ; v1(55.72,83.18) 55.03,82.48 CE9.2 CE8.2 ; v1(208.14,48.19) 208.14,47.76 208.75,47.15 PCB13.2 ; PR45.2 209.27,49.98 PQ13.1 v1(210.2,49.73) ; CA28.2 v1(24.92,6.15) ; R17.2 v1(222.79,56.13) ; v1(183.74,72.64) 184.02,72.36 C27.2 ; PCG108.2 127.67,85.9 v1(127.67,86.29) ; PRV10.2 69.58,134.63 v1(69.38,134.42) ; CD43.2 57.32,53.4 v1(56.98,53.74) ; CZ11.2 v1(153.96,42.98) ; PRV05.2 PRV04.2 PRV02.2 73.19,135.07 v1(72.68,135.58) ; v1(72.18,107.19) 71.98,106.99 CD46.2 ; RC74.1 117.38,52.21 117.86,51.72 v1(117.86,51.68) ; RE32.2 30.87,72.75 v1(30.48,72.37) 30.93,71.92 CE12.2 ; PDM01.2 36.08,23.12 v1(35.59,22.63) ; UU2.2 202.36,31.73 v1(201.14,32.95) ; v1(56.93,70.04) 57.25,69.72 CD51.2 RD23.2 ; CZ12.2 150.53,37.98 v1(150.53,37.38) ; CC58.2 121.57,50.29 v1(121.77,50.49) ; RL7.1 19.02,79.76 v1(18.87,79.92) 18.87,80.31 CL7.2 ; CT18.2 12.19,122.61 v1(12.61,122.2) ; RV165.2 58.96,124.77 v1(58.71,124.52) 59.14,124.09 CV32.1 ; CC70.2 97.11,46.11 v1(97.24,46.24) ; SW1.2 v1(28.03,61.15) ; PCI128.2 122.91,68.13 v1(122.91,68.51) ; v1(33.15,71.48) 32.7,71.48 32.2,70.97 CE25.2 ; CZ15.2 38.25,59.89 v1(38.41,59.72) ; 146.14,59.55 145.93,59.75 CC53.2 ; 146.14,59.55 146.14,60.46 145.83,60.76 CC54.2 ; 146.14,59.55 v1(146.16,59.53) ; CT17.2 11.85,119.82 12.1,119.57 v1(12.48,119.57) ; v1(81.19,33.02) 81.19,33.24 RX14.2 81.59,33.66 81.56,33.69 CX7.2 ; PCI113.2 124.18,68.13 v1(124.18,68.51) ; v1(191.44,66.06) 191.78,65.72 CO1.2 192.05,65.01 191.93,64.89 CO3.2 ; v1(17.84,83.99) 17.84,83.96 17.84,83.96 YL1.4 ; RD24.2 57.85,64.94 57.74,64.94 57.52,64.72 v1(56.93,64.72) ; v1(72.75,78.26) 72.63,78.15 CD19.2 ; R2.2 67.73,30.73 v1(67.53,30.92) ; RC94.2 CC75.2 93.08,53.37 v1(93.08,52.78) ; v1(38.79,54.92) 39.09,55.22 CZ18.2 ; v1(32.98,64.37) 33.14,64.53 CE14.2 ; CD47.2 57.2,105.93 v1(56.87,105.6) ; v1(66.58,130.36) 66.32,130.09 PRV16.2 PCV20.2 66.2,128.28 PRV18.2 ; PC3.2 v1(84.17,149.41) ; PCI114.2 125.45,68.13 v1(125.45,68.51) ; v1(64.6,76.8) 64.72,76.67 CD50.2 ; v1(127.99,68.51) 127.99,68.13 PCI116.2 ; v1(67.41,136.9) 67.73,137.22 CW3.2 CW4.2 ; PC317.2 19.44,48.19 v1(19.01,47.77) ; PC2502.2 v1(64.3,115.63) ; CO2.2 190.72,66.73 190.21,66.23 v1(190.21,65.97) ; v1(124.05,75.75) 124.05,75.37 PCI102.2 ; PRH02.2 PCH09.2 164.03,44.37 163.67,44.73 v1(163.67,45.58) ; v1(73.82,37.19) 73.67,37.33 73.56,37.45 CZ23.2 ; v1(157.96,78.42) 157.96,78.04 PCI123.2 ; v1(37.37,85.02) 36.98,85.41 DE1.2 ; v1(157.96,76) 157.96,75.62 PCI126.2 ; YL1.2 15.51,80.68 v1(15.08,81.11) ; CE15.2 35.33,86.88 34.77,86.31 v1(34.77,85.85) ; v1(58.27,28.75) 59.77,30.25 C33.2 ; CC68.2 94.95,48.31 95.75,47.52 v1(96.26,47.52) ; ED4.1 221.14,48.32 v1(221.37,48.09) ; RT17.1 v1(23.66,127.19) ; v1(77.32,79.95) 77.33,79.94 CD21.2 ; PCC02.2 130.07,76.5 v1(130.31,76.75) ; v1(35.39,88.87) 34.99,88.87 34.21,89.64 RE44.1 ; CU10.2 23.31,37.36 v1(22.7,37.97) 22.64,38.03 21.95,38.03 CU9.2 ; v1(90.6,31.13) 90.05,31.68 RX22.1 ; RC15.2 120.55,57.84 v1(120.59,57.79) ; v1(102.36,52.86) 102.64,53.14 CC3.2 ; v1(127.86,75.75) 127.86,75.37 PCI124.2 ; v1(156.63,78.42) 156.63,78.04 PCI129.2 ; v1(92.05,43.37) 92.05,42.93 92.46,42.52 CC69.2 92.85,42.53 CC78.1 ; CC15.2 130.87,58.57 v1(130.84,58.6) ; v1(216.38,59.42) 215.7,59.42 215.68,59.43 C5.2 ; DA1.1 v1(22.64,5.77) ; CD48.2 56.78,96.71 v1(56.76,96.69) ; PRB04.2 196.33,62.49 v1(195.93,62.1) ; v1(223.36,29.14) 223.06,29.45 JVGA1.18 ; CE5.2 v1(43.61,87) ; v1(91.76,56.54) 92.36,55.94 RC105.2 ; v1(93.26,31.66) 93.1,31.5 CX2.2 CX1.2 ; RC124.2 130.3,53.31 v1(129.95,53.66) ; PCI130.2 126.59,75.37 v1(126.59,75.75) ; v1(128.84,121.92) 128.84,121.41 128.59,121.15 RV18.1 ; v1(147.86,80.51) 147.23,81.15 RC139.2 ; CE13.2 CE20.1 55.03,79.05 55.47,79.5 55.47,81.08 54.77,81.78 53.21,81.78 53.16,81.83 v1(53.04,81.83) ; PR40.2 v1(169.58,36.71) ; RC205.1 RC120.2 121.8,53.54 v1(121.8,53.11) ; v1(119.34,51.63) 119.82,51.15 RC73.1 ; CD23.2 72.25,73.97 v1(72.3,74.02) ; CX7.2 CX6.2 ; CX7.2 81.56,34.46 81.54,34.49 CX5.2 ; v1(90.72,37.31) 91.26,37.31 CX4.2 CX3.2 ; CL2.2 19.55,87.61 UL2.2 18.77,87.61 18.43,87.28 v1(18.43,86.66) ; v1(27.87,79.37) 28.04,79.54 CL10.2 29.14,79.54 29.7,78.98 CL17.2 ; PCM11.2 v1(50.4,27.96) ; PCW13.2 v1(148.94,112.67) ; PCI108.2 155.42,70.8 v1(155.42,71.18) ; U1.2 218.37,57.08 v1(218.73,56.72) ; RD12.2 70,66.53 v1(69.72,66.8) ; v1(98.48,49.92) 99.22,49.92 99.83,50.53 RC10.1 ; RE57.2 v1(39.72,93.01) ; CL1.2 19.04,83.67 v1(18.91,83.8) ; v1(32.98,73.2) 32.98,73.27 33.24,73.54 CE3.1 ; v1(129.26,68.51) 129.26,68.13 PCI101.2 ; PD3.2 v1(50.44,133.52) ; RC168.2 144.99,74.61 v1(147.1,74.61) ; RL9.2 23.71,88.07 24.01,88.37 24.01,89.11 v1(24.37,89.47) ; C4.1 216.59,29.51 v1(217.39,28.71) ; v1(95.9,39.55) 95.9,39.73 96.74,40.57 96.74,41.17 97.11,41.54 CC67.2 96.33,41.84 96.09,41.61 95.67,41.61 95.18,41.12 Q7.3 ; RT18.1 21.56,126.18 v1(22.01,125.73) ; PC508.2 23.95,98.58 v1(23.93,98.6) ; DA5.1 v1(21.05,21.71) ; v1(35.28,67.52) 35.67,67.13 CE32.1 ; EC2.2 v1(224.27,64.52) ; C9.2 211.54,55.62 v1(211.21,55.62) ; CZ20.2 72.94,31.17 73.45,30.67 73.45,29.03 v1(72.74,28.32) ; v1(157.96,71.18) 157.96,70.8 PCI120.2 ; v1(118.6,62.56) 118.6,62.03 118.53,61.98 RC17.2 ; CE2.2 37.61,65.23 v1(37.64,65.2) ; PCZ33.2 v1(173.47,64.64) ; v1(143.48,67.88) 143.72,67.64 RC165.2 ; v1(82.9,129.73) PCV11.2 PCV12.2 ; PD14.1 v1(183.42,43.62) ; PCI118.2 152.88,70.8 v1(152.88,71.18) ; RC61.1 125.48,52.97 v1(124.94,52.97) ; RC157.2 146.21,82.67 v1(146.34,82.8) ; CE17.2 CE4.1 ; CE17.2 CE23.2 ; CE17.2 44.74,64 v1(44.99,63.75) ; PQB31.3 198.73,46.72 PRB45.2 198.03,46.35 v1(198.28,46.1) ; v1(129.91,54.32) 129.99,54.41 CC49.2 ; v1(23.08,43.68) 23.08,43.42 PC309.2 ; v1(105.2,112.83) 105.2,112.13 105.7,111.63 CC1.2 CC2.2 ; CD45.2 58.8,80.03 v1(59.85,81.08) ; CD49.2 64.91,70.49 v1(64.57,70.84) ; v1(178.41,62.68) 178.79,62.3 PCZ24.2 ; RT20.1 21.88,118.49 v1(22.07,118.3) ; ED1.1 v1(224.32,66.1) ; v1(160.31,139.93) 160.97,140.58 CV152.2 ; PDB13.1 179.04,47.62 v1(178.47,47.05) ; RV53.2 RV135.2 v1(164.9,141.85) ; PHZ04.2 170.66,51.99 v1(170.34,52.31) ; v1(24.29,37.71) 24.7,37.3 CU12.2 ; PC509.2 v1(19.1,103.07) ; v1(91.78,35.25) 92.55,34.47 RX11.1 ; DA7.1 v1(17.11,20.76) ; PC4.2 v1(85.19,149.41) ; RL11.1 v1(15.19,88.67) ; v1(130.55,43.03) 131.65,43.03 132.19,43.57 R53.2 ; v1(128.99,118.56) 129.6,119.17 RV40.1 ; RV29.1 118.33,139.77 118.49,139.93 119.09,139.93 RV59.1 119.18,140.54 v1(119.01,140.72) ; v1(126.49,86.29) 126.49,85.88 PCG110.2 ; PQ11.3 163.1,35.29 162.59,35.79 v1(162.59,36.6) 162.59,36.7 PD5.1 ; CS3.2 v1(28.75,27.74) ; v1(115.66,51.44) 115.66,51.65 116.21,52.21 RC54.1 ; v1(215.87,60.26) 215.55,60.57 C6.2 ; PR6.2 v1(56.98,135.36) ; RC125.2 RC123.2 146.4,54.8 v1(146.66,54.54) ; v1(67.22,132.33) PRV09.2 ; PCV10.2 69.57,131.54 v1(69.71,131.68) ; v1(51.85,131) 51.74,131.11 PD2.2 ; v1(130.12,51.08) 130.43,51.08 130.67,51.32 RC13.1 ; v1(71.74,120.38) 71.9,120.54 PCV31.2 ; R65.1 59.33,34.3 59.09,34.54 v1(59.09,35.11) C2.2 ; v1(216.82,47.26) 216.48,47.26 R76.1 ; CW2.2 69.13,116.19 CW1.2 67.61,116.18 v1(67.19,115.75) ; PCM16.2 32.32,30.06 32.08,29.82 v1(32.08,29.54) 32.48,29.13 PCM15.2 ; v1(16.16,2.47) 16.67,2.98 DA2.1 ; v1(77.32,78.26) 77.35,78.29 CD22.2 ; PCZ03.2 181.37,56.72 182.15,56.72 PRZ01.2 182.74,56.74 v1(182.81,56.82) ; v1(123.18,43.02) 123.18,43.13 123.48,43.42 RC108.1 ; v1(100.6,58.27) 100.57,58.27 100.36,58.48 CC13.2 ; CS4.2 v1(28.75,25.08) ; CD44.2 59.11,75.88 v1(60.03,76.8) ; CE1.2 55.09,84.51 v1(55.72,83.88) ; v1(19.59,7.68) RA16.2 ; v1(156.63,76) 156.63,75.62 PCI119.2 ; EC1.2 v1(219.92,66.05) ; CU11.2 19.15,34.03 v1(18.7,33.59) ; v1(156.69,71.18) 156.69,70.8 PCI125.2 ; R75.1 v1(217.64,51.67) ; EU10.1 16.8,121.47 v1(17.18,121.85) ; RT19.1 v1(23.91,118.98) ; CE7.2 31.94,79.81 31.8,79.68 v1(31.44,79.68) ; RC156.2 v1(145.89,84.96) ; v1(49.9,87.9) CE30.2 RE24.2 CE16.2 ; CI9.2 v1(14.05,102.24) ; DA6.1 v1(18,7.91) ; v1(134.15,122.23) 134.1,122.17 CV91.2 ; PQ2.3 54.25,135.46 v1(54.01,135.69) ; CE28.2 v1(55.06,71.8) ; v1(154.15,71.18) 154.15,70.8 PCI103.2 ; CD18.2 78.93,102.02 v1(77.83,102.02) ; Q18.3 61.9,37.03 62.02,37.15 v1(62.02,38.17) ; JVGA1.17 v1(221.25,39.59) ; v1(69.38,61.77) 70.28,62.67 RD13.2 ; QI1.3 25.1,91.88 v1(24.55,91.32) ; C25.2 C24.2 128.44,29.24 128.05,29.64 126.76,29.64 v1(126.56,29.44) ; PR43.2 v1(163.47,38.68) ; RV43.2 v1(99.54,117.72) ; PD6.1 v1(167.42,41.65) ; CU17.2 202.76,38.23 v1(202.76,38.92) ; RC64.2 126.86,48.17 RC71.2 ; v1(131.44,47.56) CC57.2 ; CV27.2 v1(111.98,131.95) ; RE45.1 v1(37.12,88.27)
  GND1 w0.254: JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.1,116.1 ; 1.67,65.08 JLAN1.11 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,66.42 ; JLAN1.11 1.67,65.75 ; JLAN1.11 2.85,65.08 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,65.08 ; JLAN1.11 4.03,65.75 ; JLAN1.9 11.83,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 10.65,83.22 ; JLAN1.9 11.83,82.55 ; JLAN1.9 9.47,81.88 ; JLAN1.9 11.83,83.22 ; JLAN1.9 9.47,83.22 ; JLAN1.9 9.47,82.55 ; 9.47,65.08 JLAN1.12 ; JLAN1.12 10.65,65.08 ; JLAN1.12 11.83,65.08 ; JLAN1.12 10.65,66.42 ; JLAN1.12 11.83,65.75 ; JLAN1.12 9.47,66.42 ; JLAN1.12 11.83,66.42 ; JLAN1.12 9.47,65.75 ; H4.1 7.9,87.73 ; H4.1 6.48,84.38 ; H4.1 5.97,85.8 ; H4.1 9.83,85.8 ; H4.1 9.32,84.38 ; H4.1 7.9,83.87 ; H4.1 6.48,87.22 ; H4.1 9.32,87.22 ; 10.59,94.81 JHDMI1.5 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.51,93.89 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 5.37,116.1 ; HCPU1.1 113.08,103.2 ; HCPU1.1 114.82,102.55 ; HCPU1.1 111.34,99.07 ; HCPU1.1 111.34,102.55 ; HCPU1.1 115.47,100.81 ; HCPU1.1 114.82,99.07 ; HCPU1.1 110.69,100.81 ; HCPU1.1 113.08,98.42 ; 2.02,106 JHDMI1.21 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,105.07 ; 10.47,100.35 JHDMI1.17 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 10.59,99.89 ; HCPU2.1 139.12,102.52 ; HCPU2.1 135.64,99.04 ; HCPU2.1 135.64,102.52 ; HCPU2.1 139.12,99.04 ; HCPU2.1 137.38,98.39 ; HCPU2.1 134.99,100.78 ; HCPU2.1 139.77,100.78 ; HCPU2.1 137.38,103.16 ; 123.98,153.05 H11.1 ; H11.1 126.01,155.08 ; H11.1 127.5,151.56 ; H11.1 128.04,153.05 ; H11.1 124.52,154.54 ; H11.1 127.5,154.54 ; H11.1 124.52,151.56 ; H11.1 126.01,151.02 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.1 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.98 ; JUSB2.11 7.77,21.4 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 5.03,20.52 ; JUSB1.10 15.28,46.18 ; JUSB1.10 15.28,44.42 ; JUSB1.10 13.5,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 11.72,45.3 ; 11.47,89.6 JHDMI1.23 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,90.53 ; HCPU4.1 139.12,41.55 ; HCPU4.1 135.64,41.55 ; HCPU4.1 137.38,37.42 ; HCPU4.1 134.99,39.81 ; HCPU4.1 137.38,42.19 ; HCPU4.1 139.77,39.81 ; HCPU4.1 139.12,38.07 ; HCPU4.1 135.64,38.07 ; JUSB2.12 15.28,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.1 ; JUSB2.12 11.72,37.98 ; 101.31,128.16 H10.1 ; H10.1 101.31,132.53 ; H10.1 99.71,128.75 ; H10.1 102.91,131.94 ; H10.1 103.49,130.35 ; H10.1 99.71,131.94 ; H10.1 102.91,128.75 ; H10.1 99.13,130.35 ; H8.1 8.42,114.12 ; H8.1 6.9,114.68 ; H8.1 8.42,111.08 ; H8.1 5.38,114.12 ; H8.1 6.9,110.52 ; H8.1 4.82,112.6 ; H8.1 5.38,111.08 ; H8.1 8.98,112.6 ; 5.03,61.88 JUSB1.13 ; JUSB1.13 7.77,61 ; JUSB1.13 5.03,61 ; JUSB1.13 7.77,61.88 ; JUSB1.13 6.4,61.88 ; 5.43,129.08 H1.1 ; H1.1 6.85,132.43 ; H1.1 6.85,128.57 ; H1.1 4.92,130.5 ; H1.1 8.27,131.92 ; H1.1 8.78,130.5 ; H1.1 5.43,131.92 ; H1.1 8.27,129.08 ; H9.1 142.95,119.36 ; H9.1 142.95,114.99 ; H9.1 144.55,115.58 ; H9.1 145.13,117.18 ; H9.1 140.77,117.18 ; H9.1 144.55,118.77 ; H9.1 141.35,118.77 ; H9.1 141.35,115.58 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.06,96.31 ; 206.03,65.27 H6.1 ; H6.1 206.03,62.43 ; H6.1 209.38,63.85 ; H6.1 207.45,65.78 ; H6.1 208.87,62.43 ; H6.1 205.52,63.85 ; H6.1 208.87,65.27 ; H6.1 207.45,61.92 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,124.29 ; 3.27,87.7 JHDMI1.22 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 5.83,87.7 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,28.72 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.91,28.72 ; JUSB2.7 15.05,29.25 ; JUSB2.7 13.85,29.78 ; H13.1 216.28,67.43 ; H13.1 213.85,67.43 ; H13.1 216.28,63.57 ; H13.1 216.28,65.5 ; H13.1 211.42,63.57 ; H13.1 211.42,65.5 ; H13.1 213.85,63.57 ; H13.1 211.42,67.43 ; 45.5,127.87 H12.1 ; H12.1 47.53,129.9 ; H12.1 43.47,129.9 ; H12.1 45.5,131.93 ; H12.1 44.01,131.39 ; H12.1 46.99,131.39 ; H12.1 44.01,128.41 ; H12.1 46.99,128.41 ; HCPU3.1 114.82,38.07 ; HCPU3.1 111.34,38.07 ; HCPU3.1 110.69,39.81 ; HCPU3.1 114.82,41.55 ; HCPU3.1 111.34,41.55 ; HCPU3.1 113.08,42.19 ; HCPU3.1 113.08,37.42 ; HCPU3.1 115.47,39.81 ; 15.35,50.18 JUSB1.4 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.41,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.21,49.65 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.35,49.12 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.91,53.68 ; JUSB1.7 14.38,53.82 ; JUSB1.7 13.85,53.68 ; JUSB1.7 13.85,52.62 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,52.48 ; JUSB2.10 15.28,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 15.28,21.4 ; JUSB2.10 13.5,20.52 ; JUSB2.10 11.72,20.52 ; JUSB2.10 15.28,22.28 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.35,26.28 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.55,25.75 ; 11.72,61.88 JUSB1.12 ; JUSB1.12 15.28,61 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,61.88 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; 1.67,82.55 JLAN1.10 ; JLAN1.10 4.03,82.55 ; JLAN1.10 4.03,81.88 ; JLAN1.10 2.85,83.22 ; JLAN1.10 1.67,81.88 ; JLAN1.10 2.85,81.88 ; JLAN1.10 1.67,83.22 ; JLAN1.10 4.03,83.22 ; H5.1 9.42,39.78 ; H5.1 9.93,41.2 ; H5.1 6.07,41.2 ; H5.1 8,39.27 ; H5.1 9.42,42.62 ; H5.1 6.58,39.78 ; H5.1 8,43.13 ; H5.1 6.58,42.62 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 3.02,116.88 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 3.02,124.69 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 12.02,92.85 ; 5.37,126.29 JUSBC1.1 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,126.29 ; 139.62,27.1 H7.1 ; H7.1 140.13,25.68 ; H7.1 140.13,28.52 ; H7.1 142.97,25.68 ; H7.1 141.55,29.03 ; H7.1 141.55,25.17 ; H7.1 142.97,28.52 ; H7.1 143.48,27.1 ; 6.4,44.42 JUSB1.11 ; JUSB1.11 5.03,44.42 ; JUSB1.11 7.77,44.42 ; JUSB1.11 7.77,45.3 ; JUSB1.11 5.03,45.3 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,103.17 ; 10.59,96.89 JHDMI1.11 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 11.63,97.35
  VCC w0.203: 15.35,26.28 JUSB2.4 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.21,25.75 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.41,26.28 ; 6.58,42.62 H5.1 ; H5.1 6.58,39.78 ; H5.1 9.42,42.62 ; H5.1 9.93,41.2 ; H5.1 8,43.13 ; H5.1 9.42,39.78 ; H5.1 8,39.27 ; H5.1 6.07,41.2 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,66.42 ; JLAN1.11 2.85,65.08 ; JLAN1.11 1.67,65.08 ; JLAN1.11 4.03,65.75 ; JLAN1.11 4.03,65.08 ; JLAN1.11 1.67,65.75 ; JLAN1.11 1.67,66.42 ; 5.03,21.4 JUSB2.11 ; JUSB2.11 7.77,21.4 ; JUSB2.11 5.03,20.52 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; 15.35,49.12 JUSB1.4 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.21,49.65 ; 5.03,44.42 JUSB1.11 ; JUSB1.11 6.4,44.42 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,45.3 ; JUSB1.11 7.77,45.3 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,45.3 ; JUSB1.10 13.5,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 15.28,44.42 ; 13.85,52.62 JUSB1.7 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.91,52.62 ; JUSB1.7 15.05,53.15 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.91,53.68 ; 9.47,65.08 JLAN1.12 ; JLAN1.12 11.83,65.08 ; JLAN1.12 11.83,65.75 ; JLAN1.12 11.83,66.42 ; JLAN1.12 9.47,66.42 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,66.42 ; JLAN1.12 10.65,65.08 ; JUSB2.10 15.28,20.52 ; JUSB2.10 11.72,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 13.5,20.52 ; JUSB2.10 15.28,22.28 ; JUSB2.10 15.28,21.4 ; JUSB2.12 15.28,37.98 ; JUSB2.12 15.28,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 15.28,36.22 ; JUSB1.12 13.5,61.88 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,60.12 ; JUSB1.12 15.28,61 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,61.88 ; JUSB2.7 14.91,29.78 ; JUSB2.7 13.85,29.78 ; JUSB2.7 14.38,28.58 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,28.72 ; JUSB2.7 15.05,29.25 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.1 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.98 ; JUSB1.13 7.77,61 ; JUSB1.13 6.4,61.88 ; JUSB1.13 7.77,61.88 ; JUSB1.13 5.03,61.88 ; JUSB1.13 5.03,61
  VCC w0.254: 12.6,92.26 JHDMI1.2 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.14,93.31 ; JHDMI1.21 4.58,106 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,106 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 4.58,105.07 ; 11.47,104.1 JHDMI1.20 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,103.17 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,82.55 ; JLAN1.10 4.03,81.88 ; JLAN1.10 4.03,83.22 ; JLAN1.10 1.67,82.55 ; JLAN1.10 1.67,81.88 ; JLAN1.10 1.67,83.22 ; JLAN1.10 2.85,81.88 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 11.47,89.6 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 10.59,96.89 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 11.51,93.89 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,116.88 ; 5.38,111.08 H8.1 ; H8.1 6.9,110.52 ; H8.1 8.42,111.08 ; H8.1 8.98,112.6 ; H8.1 8.42,114.12 ; H8.1 6.9,114.68 ; H8.1 5.38,114.12 ; H8.1 4.82,112.6 ; H4.1 7.9,87.73 ; H4.1 9.32,87.22 ; H4.1 9.83,85.8 ; H4.1 6.48,84.38 ; H4.1 5.97,85.8 ; H4.1 7.9,83.87 ; H4.1 9.32,84.38 ; H4.1 6.48,87.22 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 3.27,87.7 ; 10.59,100.81 JHDMI1.17 ; JHDMI1.17 10.47,100.35 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 5.37,116.88 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.02,95.85 ; 10.65,81.88 JLAN1.9 ; JLAN1.9 11.83,81.88 ; JLAN1.9 9.47,82.55 ; JLAN1.9 9.47,83.22 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,81.88 ; JLAN1.9 11.83,83.22 ; JLAN1.9 11.83,82.55 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 6.1,126.3 ; 5.37,125.52 JUSBC1.1 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,124.74 ; 5.43,129.08 H1.1 ; H1.1 6.85,128.57 ; H1.1 6.85,132.43 ; H1.1 8.78,130.5 ; H1.1 8.27,131.92 ; H1.1 8.27,129.08 ; H1.1 4.92,130.5 ; H1.1 5.43,131.92 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.82,116.1
  IN3 w0.135: 116.66,59.75 117.2,60.29 117.56,60.29 v1(117.96,60.7)
  IN3 w0.254: 116.66,59.75 115.89,58.98 v1(115.59,58.98) 115.4,58.79 115.4,57.23 114.21,56.04 113.06,56.04 109.05,52.03 106.64,52.03 106.18,51.57 106.18,48.83 105.93,48.57 v1(105.89,48.57) 105.43,48.12 103.62,48.12 v1(103.6,48.13) 103.37,48.36 103.37,48.72 104.5,49.86 104.5,52.35 105.79,53.63 108.38,53.63 112.52,57.77 113.38,57.77 113.7,58.09 113.7,58.62 v1(113.34,58.98) 115.63,61.27 v1(115.63,61.62) 117.29,61.62 117.96,60.95 v1(117.96,60.7)
  GND2 w0.254: JHDMI1.21 4.58,106.93 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 4.58,106 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 4.58,105.07 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.1,116.1 ; 43.47,129.9 H12.1 ; H12.1 44.01,128.41 ; H12.1 46.99,131.39 ; H12.1 44.01,131.39 ; H12.1 47.53,129.9 ; H12.1 45.5,127.87 ; H12.1 45.5,131.93 ; H12.1 46.99,128.41 ; 1.67,65.75 JLAN1.11 ; JLAN1.11 1.67,65.08 ; JLAN1.11 4.03,65.75 ; JLAN1.11 4.03,66.42 ; JLAN1.11 2.85,66.42 ; JLAN1.11 2.85,65.08 ; JLAN1.11 1.67,66.42 ; JLAN1.11 4.03,65.08 ; 10.59,99.89 JHDMI1.17 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.47,100.35 ; JUSB1.12 15.28,60.12 ; JUSB1.12 15.28,61 ; JUSB1.12 11.72,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,61.88 ; 10.47,94.35 JHDMI1.5 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 11.51,94.81 ; 6.85,128.57 H1.1 ; H1.1 5.43,129.08 ; H1.1 5.43,131.92 ; H1.1 4.92,130.5 ; H1.1 8.78,130.5 ; H1.1 8.27,129.08 ; H1.1 6.85,132.43 ; H1.1 8.27,131.92 ; 207.45,61.92 H6.1 ; H6.1 209.38,63.85 ; H6.1 206.03,62.43 ; H6.1 206.03,65.27 ; H6.1 208.87,62.43 ; H6.1 207.45,65.78 ; H6.1 205.52,63.85 ; H6.1 208.87,65.27 ; 5.38,124.29 JUSBC1.2 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,125.22 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.35,49.12 ; JUSB1.4 16.41,50.18 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.21,49.65 ; JUSB1.4 15.88,48.98 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,28.58 ; JUSB2.7 13.85,28.72 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.38,29.92 ; JUSB2.7 14.91,28.72 ; JUSB2.7 13.85,29.78 ; JLAN1.9 11.83,83.22 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,81.88 ; JLAN1.9 10.65,81.88 ; JLAN1.9 9.47,83.22 ; JLAN1.9 9.47,82.55 ; JLAN1.9 11.83,81.88 ; JLAN1.9 11.83,82.55 ; 134.99,39.81 HCPU4.1 ; HCPU4.1 139.77,39.81 ; HCPU4.1 139.12,41.55 ; HCPU4.1 139.12,38.07 ; HCPU4.1 137.38,37.42 ; HCPU4.1 137.38,42.19 ; HCPU4.1 135.64,41.55 ; HCPU4.1 135.64,38.07 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,105.03 ; 12.14,92.39 JHDMI1.2 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 13.06,93.31 ; JUSB2.11 7.77,20.52 ; JUSB2.11 6.4,20.52 ; JUSB2.11 5.03,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 7.77,21.4 ; JLAN1.10 4.03,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 2.85,81.88 ; JLAN1.10 1.67,83.22 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,83.22 ; JLAN1.10 4.03,82.55 ; JLAN1.10 1.67,81.88 ; 141.35,118.77 H9.1 ; H9.1 145.13,117.18 ; H9.1 144.55,115.58 ; H9.1 140.77,117.18 ; H9.1 142.95,119.36 ; H9.1 144.55,118.77 ; H9.1 142.95,114.99 ; H9.1 141.35,115.58 ; JUSB2.10 15.28,22.28 ; JUSB2.10 13.5,20.52 ; JUSB2.10 11.72,21.4 ; JUSB2.10 11.72,20.52 ; JUSB2.10 15.28,20.52 ; JUSB2.10 15.28,21.4 ; 6.58,39.78 H5.1 ; H5.1 9.42,42.62 ; H5.1 9.42,39.78 ; H5.1 6.58,42.62 ; H5.1 6.07,41.2 ; H5.1 8,39.27 ; H5.1 8,43.13 ; H5.1 9.93,41.2 ; JUSBC1.5 1.6,126.35 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 3.02,124.69 ; 126.01,151.02 H11.1 ; H11.1 127.5,154.54 ; H11.1 126.01,155.08 ; H11.1 128.04,153.05 ; H11.1 124.52,154.54 ; H11.1 124.52,151.56 ; H11.1 123.98,153.05 ; H11.1 127.5,151.56 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 3.27,86.77 ; 5.38,111.08 H8.1 ; H8.1 5.38,114.12 ; H8.1 4.82,112.6 ; H8.1 8.42,111.08 ; H8.1 8.42,114.12 ; H8.1 6.9,110.52 ; H8.1 8.98,112.6 ; H8.1 6.9,114.68 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 11.51,97.81 ; 111.34,41.55 HCPU3.1 ; HCPU3.1 113.08,42.19 ; HCPU3.1 115.47,39.81 ; HCPU3.1 110.69,39.81 ; HCPU3.1 113.08,37.42 ; HCPU3.1 114.82,41.55 ; HCPU3.1 114.82,38.07 ; HCPU3.1 111.34,38.07 ; 113.08,98.42 HCPU1.1 ; HCPU1.1 114.82,102.55 ; HCPU1.1 111.34,99.07 ; HCPU1.1 110.69,100.81 ; HCPU1.1 113.08,103.2 ; HCPU1.1 114.82,99.07 ; HCPU1.1 115.47,100.81 ; HCPU1.1 111.34,102.55 ; 15.35,25.22 JUSB2.4 ; JUSB2.4 15.35,26.28 ; JUSB2.4 16.41,26.28 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.88,26.42 ; JUSB2.4 15.88,25.08 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.21,25.75 ; H4.1 7.9,87.73 ; H4.1 9.32,87.22 ; H4.1 6.48,84.38 ; H4.1 6.48,87.22 ; H4.1 9.83,85.8 ; H4.1 7.9,83.87 ; H4.1 9.32,84.38 ; H4.1 5.97,85.8 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,89.6 ; 5.03,37.1 JUSB2.13 ; JUSB2.13 5.03,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 7.77,37.98 ; JUSB2.13 6.4,37.98 ; H10.1 102.91,131.94 ; H10.1 99.71,131.94 ; H10.1 103.49,130.35 ; H10.1 99.13,130.35 ; H10.1 102.91,128.75 ; H10.1 99.71,128.75 ; H10.1 101.31,128.16 ; H10.1 101.31,132.53 ; HCPU2.1 139.77,100.78 ; HCPU2.1 137.38,98.39 ; HCPU2.1 137.38,103.16 ; HCPU2.1 134.99,100.78 ; HCPU2.1 135.64,102.52 ; HCPU2.1 135.64,99.04 ; HCPU2.1 139.12,102.52 ; HCPU2.1 139.12,99.04 ; JUSB1.13 7.77,61.88 ; JUSB1.13 6.4,61.88 ; JUSB1.13 5.03,61 ; JUSB1.13 7.77,61 ; JUSB1.13 5.03,61.88 ; 5.37,126.29 JUSBC1.1 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,125.52 ; 9.47,65.08 JLAN1.12 ; JLAN1.12 10.65,65.08 ; JLAN1.12 9.47,66.42 ; JLAN1.12 11.83,66.42 ; JLAN1.12 9.47,65.75 ; JLAN1.12 11.83,65.08 ; JLAN1.12 10.65,66.42 ; JLAN1.12 11.83,65.75 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.91,53.68 ; JUSB1.7 13.85,52.62 ; JUSB1.7 14.38,52.48 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.38,53.82 ; 211.42,63.57 H13.1 ; H13.1 211.42,67.43 ; H13.1 213.85,67.43 ; H13.1 216.28,67.43 ; H13.1 213.85,63.57 ; H13.1 216.28,63.57 ; H13.1 216.28,65.5 ; H13.1 211.42,65.5 ; 11.72,37.1 JUSB2.12 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 15.28,37.98 ; JUSB2.12 13.5,37.98 ; 12.14,95.39 JHDMI1.8 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 12.02,95.85 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,116.88 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 3.02,117.71 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,44.42 ; JUSB1.11 5.03,45.3 ; JUSB1.11 6.4,44.42 ; JUSB1.11 7.77,45.3 ; H7.1 143.48,27.1 ; H7.1 139.62,27.1 ; H7.1 140.13,28.52 ; H7.1 141.55,29.03 ; H7.1 141.55,25.17 ; H7.1 142.97,25.68 ; H7.1 142.97,28.52 ; H7.1 140.13,25.68 ; 13.5,44.42 JUSB1.10 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 15.28,46.18 ; JUSB1.10 15.28,44.42
  BOTTOM w0.09: v1(118.92,93.2) UC1.B29 ; v1(113.34,58.98) UC1.BT36 ; v1(121.44,93.2) UC1.B25
  BOTTOM w0.102: UC1.L36 114.33,86.66 113.35,86.66 v1(113.34,86.67) ; UC1.CJ11 130.6,51.09 131.07,50.61 131.07,50.21 131.34,49.94 UC1.CM9 ; v1(113.34,66.53) UC1.BD36 ; v1(113.34,71.57) UC1.AT36
  BOTTOM w0.127: PCI187.2 v3(150.67,58.11) ; UC1.V36 112.58,82.89 v1(112.57,82.9) ; PCI188.2 v3(145.96,90.47) ; v1(157.43,150.59) v3(158.62,150.59) ; v1(132.78,50.45) 132.78,50.09 133.24,49.63 133.55,49.63 134.03,49.15 UC1.CN5 ; v1(113.42,89.26) 114.26,89.26 UC1.G36 ; v1(115.32,110.42) v3(114.52,110.42) ; v3(99.48,143.82) v1(100.43,143.82) ; v3(136.77,148.74) 136.24,148.2 CV95.2 ; PCB70.2 v3(185.73,57.03) ; 199.18,61.78 v3(200.16,61.78) ; PCV172.2 v3(106.18,118.14) ; UC1.T36 114.33,84.15 113.34,84.15 v1(113.34,84.15)
  BOTTOM w0.135: UC1.CM13 129.32,49.64 129.32,49.37 UC1.CN13
  BOTTOM w0.15: UC1.CM33 116.65,50.24 116.95,50.27 117.16,50.27 117.49,50.09 117.51,50.09 v1(117.52,50.08)
  BOTTOM w0.152: UC1.AT33 116.19,70.83 116.16,70.8 116.16,70.34 UC1.AV33 ; v1(135.07,80.16) 135.16,80.07 UC1.AB3 ; UC1.CL2 136.11,50.26 135.42,50.26 135.12,49.96 UC1.CM4 ; UC1.D21 123.93,90.93 ; UC1.AM33 UC1.AK33 ; UC1.BP36 111.79,60.24 111.61,60.06 v1(110.33,60.06) ; UC1.E33 UC1.E31 UC1.E29 UC1.E27 120.96,90.35 121.15,90.54 121.15,90.61 UC1.D25 ; UC1.AV3 UC1.AW1 ; UC1.BP32 116.54,60.28 116.52,60.26 116.21,60.26
  BOTTOM w0.16: v1(117.66,93.93) 117.67,93.92 117.67,92.3 UC1.B31
  BOTTOM w0.18: UC1.BB36 112.53,67.79 v1(112.5,67.82) ; UC1.AF36 112.61,77.86 v1(112.6,77.87) ; v1(120.19,47.32) 120.27,47.39 120.27,48.24 UC1.CP27 ; UC1.AV36 112.69,70.31 112.61,70.38 112.61,70.31 v1(112.61,70.31) ; UC1.BK2 UC1.BK3 135.2,62.98 v1(135.04,62.83) 134.9,62.97 134.57,62.97 UC1.BK4 ; v1(137.69,52.59) 137.69,52.8 137.27,53.22 UC1.CF2 UC1.CF3 ; v1(120.18,93.93) 120.18,92.3 UC1.B27 ; v1(112.59,72.85) 112.61,72.82 UC1.AP36 ; v1(127.77,47.22) 127.77,47.45 127.75,47.46 UC1.CP15 ; UC1.CB3 UC1.CB2 137.07,55.66 ; UC1.AK36 v1(112.61,75.34) ; v1(112.56,65.21) 112.62,65.27 UC1.BF36 ; v1(130.1,47.28) 130.28,47.45 UC1.CP11 ; UC1.AB36 v1(112.61,80.37) ; v1(112.61,85.41) UC1.P36 ; v1(112.6,87.93) UC1.J36 ; UC1.B23 v1(122.7,93.93)
  BOTTOM w0.2: v1(115.66,51.44) 115,51.44 UC1.CJ35 ; v1(119.87,80.79) UC1.AB27 ; v1(117.97,84.43) 117.98,84.42 117.98,84.41 ; UC1.CK1 136.93,50.75 137.45,50.22 137.45,50.07 137.62,49.91 v1(137.62,49.84) ; UC1.R27 v1(119.87,85.35) ; UC1.K31 v1(117.33,88.08) ; v1(130.35,85.09) UC1.P10 ; UC1.AN30 118.04,73.37 117.99,73.38 v1(117.92,73.45) 117.92,73.43 117.87,73.38 UC1.AN31 ; v1(121.59,89.74) 122.05,90.02 UC1.F24 ; UC1.AY33 v1(115.59,69.05) UC1.AY35 ; UC1.AN28 v1(119.24,73.5) ; UC1.AM28 119.27,74.35 v1(119.24,74.41) ; v1(118.6,73.5) UC1.AN29 ; v1(118.6,69.85) UC1.AW29 ; UC1.AG10 130.34,76.77 v1(130.31,76.75) ; v1(130.08,88.4) UC1.J12 ; v1(115.59,58.98) UC1.BT33 ; UC1.AV28 119.3,70.65 v1(119.24,70.76) ; v1(118.6,71.67) UC1.AU29 ; v1(115.67,90.11) 115.59,90.11 UC1.E35 v1(115.29,90.74) ; UC1.CJ28 119.56,50.98 UC1.CM29 ; UC1.AL29 118.83,74.93 v1(118.6,75.32) ; UC1.AU28 v1(119.24,71.67) ; v1(115.59,84.15) UC1.T35 UC1.T36 ; UC1.BD36 UC1.BD35 v1(115.59,66.53) UC1.BD33 ; UC1.AM33 v1(115.59,74.08) UC1.AM35 ; UC1.BA28 v1(119.24,68.94) ; v1(115.72,56.58) 115.61,56.46 UC1.BY35 UC1.BY36 ; v1(115.63,61.62) 115.41,61.39 115.09,61.39 UC1.BM35 UC1.BM36 ; v1(130.35,79.54) UC1.AC10 ; UC1.AT36 UC1.AT35 v1(115.59,71.57) UC1.AT33 ; UC1.CN21 123.97,49.2 124.08,49.31 124.08,49.83 UC1.CM21 ; 117.96,85.32 v1(117.96,85.35) 117.99,85.35 118.22,84.92 UC1.R30 ; UC1.CJ11 v1(130.12,51.08) ; UC1.AH35 v1(115.59,76.6) ; UC1.AN25 v1(121.71,73.04) ; v1(117.97,88.08) UC1.K30 ; UC1.AW30 v1(117.97,69.85) UC1.AW31 ; 117.97,79.86 v1(117.97,79.87) ; UC1.CC24 121.51,54.35 UC1.CD24 ; UC1.CA15 UC1.BY15 v1(127.39,56.95) UC1.BW15 ; v1(130.09,90.35) UC1.F12 ; v1(119.87,86.26) UC1.N27 ; UC1.CE33 115.62,53.95 v1(115.57,53.89) 115.04,53.89 UC1.CE35 UC1.CE36 ; UC1.BE28 119.24,66.21 ; v1(119.24,56.18) UC1.BY28 ; UC1.BE30 118.01,66.13 117.94,66.15 v1(117.92,66.17) 117.92,66.16 117.92,66.15 UC1.BE31 ; UC1.G36 UC1.G35 ; UC1.E33 v1(116.41,90.95) UC1.C33 UC1.B34 ; v1(126.55,54.35) UC1.CC16 ; 118.17,82.2 117.98,82.54 117.98,82.58 v1(117.88,82.68) ; UC1.BK10 130.41,62.92 130.15,63.18 v1(130.15,63.88) ; v1(117.96,60.7) 118.22,61.17 UC1.BN30 ; 117.96,80.79 v1(117.96,80.8) ; v1(119.87,79.88) UC1.AC27 ; UC1.R29 118.61,85.34 v1(118.62,85.37) ; UC1.L33 v1(115.59,86.67) UC1.L35 ; UC1.R28 v1(119.24,85.35) ; UC1.V27 UC1.U26 UC1.U24 ; UC1.C29 UC1.B29 ; v1(119.87,84.43) UC1.T27 ; UC1.AU10 130.34,70.58 v1(130.34,70.29) ; UC1.AL28 119.47,74.93 v1(119.24,75.32) UC1.AJ28 ; UC1.CC20 124.35,54.6 v1(124.03,54.35) ; v1(130.49,68.46) UC1.BA10 ; UC1.K4 UC1.K3 ; UC1.K27 v1(119.87,87.17) ; v1(117.86,51.68) 117.86,51.78 UC1.CH31 ; UC1.AF27 v1(119.87,78.05) ; UC1.BW11 130.37,57.32 130.37,57.88 UC1.BV11 ; UC1.BE10 v1(130.35,65.69) ; UC1.BE29 v1(118.6,66.21) ; UC1.K29 v1(118.6,88.08) ; UC1.CF3 135.48,53.14 135.14,53.14 v1(135.04,53.24) 135.01,53.27 134.61,53.27 UC1.CF4 ; v1(119.24,69.85) UC1.AW28 ; v1(130.37,82.32) UC1.W10 ; v1(119.24,65.29) UC1.BG28 ; v1(130.34,74) UC1.AM10
  BOTTOM w0.203: UC1.B36 114.54,92.45 UC1.A36 v1(114.25,93.16) ; UC1.T27 120.17,83.98 UC1.U26 ; v1(132.88,56.97) 132.73,57.02 UC1.BW7 ; UC1.B12 v1(130.08,92.3) ; v1(113.71,47.04) 113.71,47.7 114.01,47.99 UC1.CR36 ; UC1.CB19 v1(125.71,55) UC1.CB18 ; UC1.CE33 116.41,53.73 116.41,53.21 116.19,53 UC1.CG33 ; UC1.Y27 UC1.Y26 UC1.V26 ; UC1.Y27 v1(119.87,81.7) UC1.W27 ; UC1.Y27 v1(119.87,80.79) ; v1(113.34,53.95) 113.39,53.99 114.29,53.99 UC1.CE36 ; UC1.AP3 135.13,72.83 v1(135.06,72.93) 134.99,72.83 UC1.AP4 134.56,72.13 UC1.AR4 134.6,71.85 UC1.AT4 134.92,71.29 UC1.AU4 134.6,70.35 UC1.AV4 ; UC1.P3 135.16,84.95 v1(135.06,84.86) 134.97,84.95 UC1.P4 ; UC1.CN2 136.22,49.43 UC1.CN1 136.69,49.1 137.11,48.69 137.11,48.35 v1(137.44,48.03) ; UC1.E29 v1(118.92,90.95) UC1.C29 ; UC1.D6 UC1.D5 133.99,90.69 v1(133.99,91.2) UC1.C4 UC1.B5 133.9,92.4 133.83,92.88 v1(133.87,92.92) ; v1(129.91,54.32) UC1.CC11 ; v1(129.91,54.32) 129.52,54.02 UC1.CD12 v1(129.95,53.66) ; v1(129.91,54.32) 130.21,54.02 130.32,54.02 ; UC1.BC8 v1(132.15,67.07) UC1.BD7 v1(132.78,66.15) UC1.BD6 v1(133.42,66.15) 133.43,66.17 v1(134.06,66.17) UC1.BE4 ; v1(129.05,47.68) 129.01,47.71 UC1.CP13 UC1.CN13 ; UC1.CD25 121.51,54.35 ; UC1.CN29 UC1.CM29 ; v1(137.13,46.98) 136.88,47.24 136.88,47.48 136.55,47.82 UC1.CP1 ; v1(134.05,67.07) UC1.BC4 UC1.BD4 ; UC1.CM4 134.71,49.94 UC1.CM5 ; UC1.CF11 129.96,53.65 129.96,53.65 v1(129.95,53.66) ; v1(137.1,73.96) 136.91,74.15 136.91,74.21 136.91,74.66 136.7,74.87 136.05,74.87 135.96,74.93 UC1.AK3 135.4,75.19 135.23,75.35 134.72,75.35 UC1.AK4 ; v1(128.19,54.99) 128.19,54.96 UC1.CC14 UC1.CD14 128.27,53.74 v1(128.25,53.74) 128.53,53.51 UC1.CF14 ; UC1.AB30 v1(117.97,79.87) ; v1(132.15,90.17) UC1.D8 UC1.D9 ; v1(125.26,47.3) 125.26,47.49 125.22,47.53 125.22,48.31 UC1.CP19 ; v1(126.55,58.25) UC1.BU16 v1(127.36,58.85) ; UV1.B16 134.58,133 134.67,132.91 134.89,132.91 v1(135.05,132.75) ; UC1.N25 UC1.N27 v1(119.87,85.35) UC1.R28 v1(119.87,84.43) ; v1(134.41,89.72) UC1.F4 UC1.F3 ; v1(132.78,50.45) UC1.CK7 ; UZ1.11 125.13,106.61 v1(125.12,106.62) ; 120.53,59.97 v1(120.54,59.95) ; 120.53,59.97 120.59,59.97 120.68,59.87 UC1.BR25 121,59.78 121,59.31 UC1.BT25 121.02,59.16 121.02,58.63 UC1.BU25 120.59,58.08 120.59,57.79 v1(120.59,57.79) ; 120.53,59.97 UC1.BP25 120.8,60.66 120.52,60.66 v1(120.46,60.72) ; v1(123.24,59.56) 123.24,59.59 UC1.BR22 ; UC1.AH33 116.19,76.18 116.22,76.15 116.22,75.75 116.19,75.73 UC1.AK33 v1(116.7,75.33) 116.88,74.93 UC1.AL32 ; UC1.AH33 v1(115.59,76.6) ; UC1.AH33 116.34,76.74 116.34,77.71 UC1.AF33 116.22,77.88 116.22,79.09 UC1.AD33 ; v1(119.24,74.41) UC1.AL29 118.91,74.93 v1(119.24,75.32) ; v1(117.32,62.55) 117.33,62.55 117.33,62.55 UC1.BL31 v1(117.97,62.56) UC1.BL30 ; v1(117.32,62.55) 116.81,62.55 116.6,62.76 UC1.BK33 116.24,62.8 116.24,63.97 UC1.BH33 ; v1(117.32,62.55) UC1.BL32 116.31,61.5 UC1.BM33 ; UC1.CG7 v1(132.78,53.22) UC1.CE7 132.78,54.14 UC1.CC7 132.56,54.61 132.75,54.98 132.57,55.51 132.55,55.53 UC1.CB7 ; UC1.Y33 v1(115.68,81.74) UC1.Y35 ; UC1.Y33 116.25,81.69 116.25,82.44 116.19,82.5 UC1.V33 116.22,82.92 116.22,84.12 UC1.T33 ; UC1.Y33 116.24,81.59 116.24,80.42 UC1.AB33 116.23,80.33 116.23,79.16 UC1.AD33 ; v1(124.87,58.25) UC1.BU20 124.07,58.28 v1(124.06,58.24) ; UC1.BG28 v1(119.16,64.43) ; v1(119.16,64.43) UC1.BH28 v1(119.24,63.47) ; v1(119.16,64.43) 118.87,63.94 UC1.BH29 ; UC1.V26 UC1.V27 v1(119.87,82.61) UC1.W27 ; UC1.V26 UC1.W27 ; UC1.J18 v1(125.39,88.41) ; v1(121.5,56.29) 121.5,56.84 UC1.BW24 ; v1(121.5,56.29) UC1.BY25 ; v1(121.5,56.29) UC1.CA25 v1(121.53,55.69) UC1.CB24 ; UC1.CD11 130.32,54.02 ; 130.32,54.02 v1(129.95,53.66) ; UC1.V30 v1(117.88,82.68) ; v1(113.4,61.58) 114.26,61.58 UC1.BM36 ; UC1.G9 131.44,89.26 v1(131.03,89.7) 131.03,89.71 UC1.E9 UC1.D9 ; UC1.AV6 v1(132.78,69.85) ; UC1.BH33 v1(116.65,64.41) ; UC1.BH33 v1(115.62,64.01) UC1.BH35 ; v1(116.65,64.41) 116.19,64.86 UC1.BF33 116.26,65.35 116.26,66.46 UC1.BD33 116.21,66.55 116.21,67.77 UC1.BB33 116.24,67.84 116.24,69 UC1.AY33 116.3,69.16 116.3,70.2 UC1.AV33 ; v1(116.65,64.41) UC1.BH32 ; UV1.AF32 116.14,144.51 v1(115.95,144.7) ; v1(117.89,57.08) 117.89,57.22 UC1.BV31 ; UC1.BL30 UC1.BN30 ; UC1.BL30 v1(118.6,62.56) UC1.BL29 v1(119.24,62.56) ; UC1.BA4 134.56,68.52 v1(134.02,68.01) 134.02,68.01 UC1.BB4 v1(135.06,67.78) ; UC1.BA4 UC1.BA3 ; UC1.BA4 UC1.AY4 ; UC1.BA3 UC1.AY4 ; UC1.BA3 v1(135.06,67.78) ; v1(119.24,88.08) UC1.K29 ; UC1.BC25 v1(121.74,67.57) ; UC1.AY4 UC1.AW3 ; UC1.D21 UC1.F21 UC1.G21 v1(123.66,89.02) UC1.H21 v1(123.63,88.37) UC1.J21 v1(123.65,87.78) UC1.K21 v1(123.64,87.17) UC1.K22 v1(122.71,87.2) UC1.K24 v1(121.59,87.84) UC1.J24 ; v1(127.36,58.85) UC1.BT15 128.13,58.97 v1(128.23,58.9) UC1.BT14 ; v1(127.36,58.85) UC1.BT16 ; v1(119.24,85.35) UC1.R29 ; UC1.BT33 116.22,59.01 116.22,59.83 116.19,59.87 UC1.BP33 116.21,60.26 116.21,61.03 116.21,61.48 UC1.BM33 ; v1(117.33,88.08) 116.91,87.66 UC1.K32 ; v1(115.29,90.74) 114.69,91.34 UC1.C36 UC1.C37 UC1.B37 v1(113.64,92.62) ; UC1.D9 v1(131.03,91.04) ; 117.94,81.71 117.94,81.72 v1(117.93,81.73) UC1.W30 118.17,82.2 ; v1(130.84,56) 130.82,55.97 UC1.CA11 UC1.BY11 ; UC1.AE30 v1(117.92,77.99) UC1.AF30 v1(117.97,77.14) UC1.AH30 v1(118.6,77.14) UC1.AH29 ; v1(119.34,51.63) 119.51,51.46 UC1.CJ28 ; v1(128.19,92.3) 128.13,92.26 UC1.B15 ; UC1.BM33 116.07,61.62 v1(115.63,61.62) ; v1(133.42,87.4) UC1.J5 v1(134.04,87.39) UC1.K4 ; v1(133.42,87.4) UC1.L6 v1(133.42,86.47) UC1.N6 v1(133.42,85.55) ; v1(133.42,87.4) UC1.J6 ; v1(132.15,72.6) 132.14,72.63 132.12,72.63 UC1.AN8 ; UC1.BF3 v1(135.07,65.28) ; v1(135.07,65.28) UC1.BG4 ; v1(135.07,65.28) UC1.BF4 UC1.BE4 ; UC1.AD33 v1(115.65,79.12) UC1.AD35 ; UC1.BP15 v1(127.37,60.18) UC1.BR16 ; UC1.CM31 117.57,50.05 v1(117.52,50.08) ; UC1.F33 v1(115.67,90.11) ; UC1.F33 UC1.G33 116.24,89.09 116.24,87.97 UC1.J33 116.24,87.88 116.24,86.99 116.24,86.71 UC1.L33 116.22,86.63 116.22,85.8 116.19,85.77 UC1.P33 116.22,85.38 116.22,84.18 UC1.T33 ; UC1.F33 UC1.E33 ; v1(121.59,89.74) 121.51,90.36 UC1.D25 UC1.C25 UC1.B25 ; v1(116.69,71.67) UC1.AU32 ; v1(116.69,71.67) 116.69,71.87 116.57,71.99 116.57,72 116.19,72.37 UC1.AP33 116.27,72.91 116.27,74 UC1.AM33 ; v1(116.69,71.67) UC1.AT33 ; UC1.AN29 v1(119.24,73.5) UC1.AM28 ; UC1.V3 UC1.V4 v1(134.13,82.8) ; UC1.BG25 v1(121.79,64.84) ; v1(135.05,70.18) UC1.AV3 ; v1(135.05,70.18) UC1.AW3 ; v1(135.05,70.18) UC1.AV4 ; UC1.BC29 v1(119.22,68.04) ; UC1.BC29 v1(119.24,67.12) UC1.BD28 119.24,66.21 ; UC1.BC29 v1(118.6,68.03) ; UC1.BY22 UC1.CA22 v1(124.01,55.65) UC1.CB20 v1(123.99,55.01) 124.23,54.83 UC1.CC20 ; UC1.BY11 130.34,56.67 130.85,56.92 v1(130.85,56.93) ; UC1.BY11 UC1.BW11 ; UC1.K31 v1(117.97,88.08) ; v1(119.24,63.47) UC1.BK28 v1(119.24,62.56) ; v1(119.24,63.47) UC1.BH29 ; UC1.CN17 126.7,49.49 v1(126.75,49.5) 126.7,49.52 UC1.CM17 ; UC1.BV3 UC1.BV4 v1(134.08,58.72) UC1.BT5 ; UC1.CP2 136.09,48.45 UC1.CR2 136.09,47.78 136.41,47.46 136.41,47.07 v1(136.5,46.98) ; UC1.Y30 v1(117.96,80.8) ; UC1.BY18 UC1.BY19 v1(124.87,56.3) ; UC1.R30 v1(117.97,84.43) UC1.R31 ; UV1.F22 132.33,137.61 v1(132.58,137.61) ; UC1.BL7 132.45,61.88 v1(132.15,61.53) ; UC1.J15 128.13,88.39 v1(128.19,88.43) ; v1(119.87,86.26) UC1.L27 v1(119.87,87.17) ; UC1.AW3 UC1.AW4 v1(134.05,69.85) UC1.AV4 ; UC1.BA6 v1(133.42,68) ; UC1.CD20 v1(124.03,54.35) ; UC1.B18 v1(125.38,92.28) ; UC1.AV25 v1(121.71,70.31) ; UC1.BU24 UC1.BU23 v1(123.22,58.22) ; UC1.AF27 v1(119.87,77.14) UC1.AH28 ; v1(118.56,64.4) UC1.BH29 ; v1(132.15,61.53) 132.15,61.53 UC1.BM9 ; v1(132.15,61.53) UC1.BN7 132.78,60.61 UC1.BP7 ; v1(150.21,35.86) 150.15,35.8 147.81,35.8 JDB1.12 ; UC1.AB4 134.09,80.07 v1(134.04,80.02) 134.04,79.74 UC1.AC5 133.8,79.54 133.44,79.9 v1(133.44,80.03) ; UC1.BR19 125.37,59.86 v1(125.75,60.18) 125.35,60.53 UC1.BP19 ; v1(131.44,47.56) 131.43,47.57 131.43,48.31 UC1.CP9 131.36,48.59 131.36,48.88 UC1.CN9 ; UC1.BY33 116.24,56.51 116.24,57.68 UC1.BV33 ; UC1.F18 v1(125.37,90.35) ; UC1.AU29 v1(119.24,71.67) UC1.AR28 v1(119.24,72.59) UC1.AN28 ; v1(135.06,67.78) UC1.BB3 ; UC1.AV8 v1(132.15,69.85) ; UC1.BK7 v1(132.79,63.39) 132.78,63.39 132.78,63.41 UC1.BJ7 ; UC1.E27 v1(119.82,89.88) UC1.G27 v1(119.84,89) UC1.H27 v1(119.83,88.07) ; v1(132.15,65.23) UC1.BE8 ; UC1.E23 UC1.F24 ; UC1.CC25 UC1.CB25 ; UC1.BL25 121.77,62.1 v1(121.83,62.16) ; UC1.AJ7 132.79,75.37 132.78,75.33 ; v1(118.6,66.21) UC1.BE30 ; v1(82.56,33) 82.95,33.4 JKB1.30 ; UC1.H9 v1(131.02,87.75) UC1.K9 ; UC1.AW30 v1(118.6,69.85) ; UC1.BE4 UC1.BE3 UC1.BD4 ; UC1.BE4 UC1.BD4 ; UC1.AB27 v1(119.87,79.88) ; UC1.BL28 v1(119.24,62.56) ; UC1.AV28 v1(119.24,69.85) UC1.AW29 ; v1(115.59,58.98) UC1.BT35 UC1.BT36 ; UC1.CC28 v1(119.84,54.4) ; UC1.AW1 136.68,69.78 v1(137.1,69.78) ; v1(119.87,78.05) UC1.AE27 ; UC1.BP12 v1(129,60.9) ; UC1.T33 v1(115.59,84.15) ; 132.78,75.33 v1(132.81,75.33) ; 132.78,75.33 132.75,75.33 132.75,75.24 132.7,75.23 UC1.AL7 v1(132.78,74.46) ; UV1.K2 128.94,122.02 v1(128.84,121.92) ; v1(132.64,92.98) 132.64,92.94 132.71,92.89 UC1.B7 ; UC1.CB3 UC1.CB4 134.21,56.01 v1(134.21,56.03) 134.21,56.03 134.05,56.03 133.85,56.24 UC1.BY5 ; v1(124.39,46.66) 124.49,46.76 124.49,47.36 124.1,47.75 124.1,48.28 UC1.CP21 UC1.CN21 ; v1(119.83,88.07) UC1.K27 ; v1(119.83,88.07) UC1.K28 ; UC1.AW28 v1(119.24,68.94) ; UC1.CF19 124.95,52.99 v1(124.94,52.97) ; v1(121.77,50.49) 121.68,50.38 121.61,50.37 121.43,50.15 UC1.CM25 UC1.CN25 ; v1(119.24,70.76) UC1.AU28 ; v1(132.8,77.21) 132.79,77.21 UC1.AF7 v1(132.78,78.16) 132.59,78.54 UC1.AE7 ; UC1.P7 v1(132.78,84.63) UC1.T7 v1(132.78,83.7) UC1.U7 v1(132.78,82.78) UC1.W7 v1(132.78,81.85) UC1.Y7 132.56,81.39 v1(132.79,80.94) UC1.AB7 v1(132.78,80.01) ; v1(130.84,58.6) 130.74,58.7 130.45,58.7 UC1.BU11 130.39,58.51 130.39,57.99 UC1.BV11 ; UC1.BT28 v1(119.24,58.91) ; v1(131.02,91.65) UC1.C9 ; v1(118.6,73.5) UC1.AN30 ; UC1.AN7 v1(132.78,72.62) ; UV1.AH32 v1(114.2,143.86) ; v1(119.87,78.97) UC1.AC27 ; UC1.L36 UC1.L35 ; UC1.A32 v1(116.91,93.13) ; v1(116.7,68.04) UC1.BC32 ; v1(118.6,88.08) UC1.K30 ; UC1.F15 v1(127.27,90.36)
  BOTTOM w0.22: v1(134.5,129.48) 134.18,129.8 UV1.B12 ; UV1.B20 134.53,136.2 v1(134.64,136.31) ; v1(135.04,134.6) UV1.B18 ; UV1.B14 134.66,131.4 v1(134.68,131.38) ; v1(135,138.36) 134.44,137.8 UV1.B22
  BOTTOM w0.25: UV1.G31 131.35,143.81 131.35,143.88 131.16,144.07 131.16,144.45 v1(131.63,144.92) ; v1(134.13,141.48) 134.14,141.48 UV1.B26 ; v1(131.39,134.64) 131.37,134.62 131.35,134.62 130.73,134 UV1.H17 ; v1(134.62,139.38) 134.6,139.38 134.6,139.4 UV1.B24
  BOTTOM w0.254: UV13.T10 149.51,143.53 v1(149.91,143.93) 150.31,144.32 UV13.R11 ; UV15.K2 v1(153.91,119.71) 154.31,119.32 UV15.K1 ; v1(112.49,143) 111.57,143 109.98,144.58 107.27,144.58 105.6,142.91 105.6,139.3 105.88,139.02 109.3,139.02 109.68,139.4 109.68,139.51 CV18.2 109.46,139.56 108.97,140.04 YV1.2 ; UV13.N12 v1(152.31,145.53) ; 154.72,146.36 154.7,146.36 154.33,146.73 UV13.K14 ; 154.72,146.36 v1(154.73,146.36) ; 154.72,146.36 154.31,145.94 UV13.K13 ; v1(137.13,46.98) 137.64,46.98 140.24,44.38 141.46,44.38 141.72,44.64 RC86.2 142.27,45.14 143.75,43.67 RC12.1 ; UC1.CD24 122.33,53.61 UC1.CF23 121.87,53.19 v1(121.8,53.11) ; UV13.M5 152.72,139.53 v1(153.12,139.93) 153.51,139.54 UV13.L5 ; UV1.AA27 120.1,141.83 v1(120.1,142.32) ; v1(151.52,143.11) UV13.P10 ; UV1.T6 124.14,125 v1(124.49,124.65) ; UV13.M10 v1(153.12,143.12) 153.51,143.51 UV13.L10 ; UV1.AE7 116.94,125.75 v1(117.29,125.4) 117.69,125 UV1.AD6 ; UV15.U1 v1(149.15,118.87) ; v1(132.62,115.13) 132.62,115.15 132.87,115.41 UZ5.5 ; v1(156.28,146.35) 156.28,146.36 UV13.H14 ; UC1.CJ2 UC1.CJ3 UC1.CJ4 134.56,51.4 UC1.CK4 134.56,50.14 UC1.CM4 ; UV1.H2 130.53,122.99 130.53,122.13 v1(130.45,122.05) ; v1(148.18,147.25) UV13.U14 ; UV13.F10 157.11,143.13 v1(157.1,143.13) 157.1,143.14 UV13.G10 ; UV15.T10 149.57,126.51 v1(149.95,126.88) ; UV15.N12 v1(152.31,127.71) ; UV15.L10 153.48,126.51 v1(153.12,126.88) 153.1,126.88 152.73,126.51 UV15.M10 ; PCH10.2 163.93,46.24 163.78,46.08 163.78,46.08 163.67,45.97 v1(163.67,45.58) 163.48,45.58 163.42,45.52 PUH01.8 ; UV15.A12 v1(161.15,127.75) 161.11,127.71 160.31,127.71 UV15.C11 ; UV1.B10 135.08,128.2 135.12,128.16 v1(135.49,128.16) ; v1(127.86,142.32) 128.14,142.04 UV1.L27 ; v1(134.19,77.32) 134.5,77.63 UC1.AF4 134.76,77.83 135.36,77.83 UC1.AF3 ; 136.13,92.79 136.09,92.75 UC1.B2 ; 136.13,92.79 v1(136.18,92.84) ; 136.13,92.79 135.79,92.79 UC1.A3 UC1.A4 ; UV1.T32 124.14,144.63 v1(124.5,144.99) ; UV13.E1 158.31,135.78 v1(158.33,135.76) ; v1(156.37,93.1) PUG01.14 ; UV15.E1 158.32,119.3 158.32,119.03 158.32,119.04 v1(158.32,118.78) ; UV13.R3 150.32,137.93 v1(150.72,137.53) ; v1(152.31,137.53) 151.91,137.93 UV13.N3 ; UC1.CC24 UC1.CB24 ; UV13.B10 160.71,143.53 160.31,143.93 v1(160.31,143.93) ; v1(124.8,144.41) 125.01,144.2 UV1.P32 ; UC1.AE30 118.19,78.54 v1(117.97,78.93) UC1.AC30 ; v1(115.72,56.58) UC1.BY33 ; UV15.F5 157.51,122.53 v1(157.12,122.92) UV15.G5 ; UV15.C3 v1(160.32,120.5) ; UV13.C12 159.91,145.13 160.31,144.73 v1(160.31,144.73) 160.31,144.72 159.91,144.33 UV13.C11 ; v1(121.53,55.69) 121.16,55.32 UC1.CB25 ; UV1.F20 132.52,136.58 v1(132.52,136.62) ; v1(126.35,144.69) 126.84,144.2 UV1.M32 ; v1(156.22,130.15) 156.22,130.02 UV15.H14 155.97,129.65 155.97,128.97 UV15.H13 ; UV15.R11 v1(149.91,127.71) UV15.R12 ; UC1.BP4 135.01,60.54 v1(135.04,60.57) 135.07,60.54 UC1.BP3 ; v1(119.7,144.76) 119.7,144.56 UV1.AB32 ; UV15.T5 v1(149.87,122.15) ; JSSD1.9 v1(37.38,35.68) ; UV13.H13 155.91,145.93 v1(156.31,145.53) ; UV13.K2 UV13.K1 154.31,135.76 v1(154.31,135.76) ; UV1.AB6 119.35,125 v1(119.72,124.63) ; v1(128.02,51.36) 128.05,51.36 128.05,51.37 128.05,51.37 128.44,51.37 UC1.CJ14 ; UV15.E12 v1(157.95,128.47) ; PCW10.2 141.74,111.2 142.45,110.49 PUW01.8 ; UC1.CP35 115.19,48.51 115.68,48.03 UC1.CR34 115.59,47.99 115.21,47.61 114.93,47.61 v1(114.54,47.22) ; v1(113.32,50.83) 113.81,50.83 UC1.CK37 113.92,51.01 UC1.CJ36 ; UV1.A30 135.09,143.4 135.13,143.36 v1(135.13,143.39) ; UV13.A12 161.51,145.13 161.91,144.73 v1(161.92,144.73) ; v1(135.12,126.29) 134.96,126.29 134.65,126.6 UV1.B8 ; UV15.R3 150.26,120.91 v1(149.86,121.31) 150.26,121.71 UV15.R4 ; UV1.F6 132.17,125 v1(132.51,124.66) ; v1(151.72,135.76) 151.91,135.94 UV13.N1 ; UV13.C1 159.91,135.87 v1(160.02,135.76) ; UC1.CL2 136.13,50.17 UC1.CM1 139.73,46.57 CC9.2 142.66,45.97 143.16,45.46 v1(144.31,45.46) 144.41,45.57 146.47,45.57 146.72,45.82 146.72,49.59 146.53,49.78 v1(143.98,49.78) 143.23,49.78 142.97,49.53 142.97,48.99 CC10.2 139.76,48.67 138.97,49.46 138.97,49.66 v1(137.64,50.99) ; UV1.B6 133.86,124.72 v1(133.75,124.72) ; UC1.CC11 130.42,54.67 v1(130.87,55.07) 130.85,55.06 UC1.CB11 ; UV1.K32 129.12,144.37 v1(129.66,144.37) 129.74,144.29 UV1.J31 ; v1(131.28,142.5) 131.28,141.86 UV1.G27 ; UV15.H2 v1(155.51,119.71) ; v1(128.45,143.37) 128.45,143.35 128.7,143.09 128.7,142.9 128.94,142.66 UV1.K28 ; UV1.G8 131.44,126.49 132.04,126.49 UV1.F8 132.37,126.6 132.42,126.55 132.61,126.55 v1(132.63,126.53) ; v1(150.2,130.27) 150.31,130.17 UV15.R14 ; UV15.D10 v1(159.51,126.91) ; v1(130.06,132.29) 130.04,132.29 130.04,131.99 130.43,131.6 UV1.H14 ; UV13.U3 148.71,137.93 v1(149.11,138.33) 149.91,138.33 UV13.R4 ; UV13.D10 159.11,143.53 158.71,143.93 v1(158.7,143.93) ; UV1.M6 127.34,124.49 v1(127.34,124.48) ; UV15.K13 UV15.K14 154.31,130.2 v1(154.34,130.23) ; v1(119.78,52.54) 119.78,52.72 UC1.CF28 ; v1(35.67,35.26) 35.87,35.06 JSSD1.15 ; UC1.AM5 v1(134.06,73.54) ; UV1.G10 131.34,128.15 v1(131.7,127.79) 132.1,128.2 UV1.F10 ; UC1.CJ23 121.84,51.08 v1(121.76,51.12) ; UV15.C1 159.91,118.95 v1(160.06,118.79) ; UV15.N1 v1(152.34,118.88) ; UC1.BW7 132.42,57.5 132.42,58.17 UC1.BU7 ; v1(211.36,47.81) 211.36,49.21 211.6,49.45 JEDP1.23 ; UV13.E3 158.31,137.93 157.91,138.33 v1(157.9,138.33) ; UV15.E14 157.9,130.12 v1(157.9,130.15) ; UV15.L5 v1(153.12,122.12) 153.1,122.12 UV15.M5 ; UV13.R1 150.31,136.22 150,135.91 v1(150,135.78) ; UC1.F3 UC1.F2 136.65,89.83 v1(136.71,89.89) ; v1(157.9,145.53) 158.3,145.13 UV13.E12 ; UC1.CR36 UC1.CP37 ; UV13.U1 v1(148.71,135.81) ; UC1.CM37 UC1.CN37 113.26,49.1 v1(113.06,48.91) ; v1(151.46,126.88) 151.11,126.53 UV15.P10 ; v1(156.14,135.8) 156.14,136.09 UV13.H1 UV13.H2 ; UV15.N14 151.91,130.26 v1(151.91,130.29) ; v1(161.88,118.94) 161.51,119.31 UV15.A1 ; v1(149.11,144.73) 148.71,145.13 UV13.U12 ; v1(185.17,34.02) 185.17,33.53 183.63,31.98 JHDD1.14 ; UV13.C14 159.91,146.73 160.31,146.33 v1(160.31,146.33) ; 137.07,55.66 v1(137.07,55.66) ; UC1.CJ33 116.18,51.49 v1(115.66,51.44) ; UV15.C4 v1(160.32,121.29) ; UV1.C1 133.78,122.6 v1(134.15,122.23) ; UV15.G10 156.73,126.51 v1(157.12,126.12) UV15.F10 ; v1(134.13,144.62) 134.13,144.59 UV1.C32 ; v1(124.88,50.99) 125,50.99 125.26,51.24 UC1.CJ19 ; UV15.N3 v1(152.32,120.49) ; UC1.CB7 132.55,55.74 v1(132.81,56) ; v1(157.9,139.13) 157.9,139.14 157.51,139.53 UV13.F5 ; v1(124.94,125.54) 125.07,125.54 125.6,125 UV1.P6 ; UV1.F26 132.14,141.16 132.52,141.54 v1(132.52,142.1) 132.52,142.18 UV1.E28 ; v1(151.9,147.25) 151.91,147.24 UV13.N14 ; v1(136.93,92.1) 136.55,91.71 UC1.C1 UC1.D1 ; v1(118.11,126.24) 117.75,126.6 UV1.AD8 ; UV15.C12 v1(159.51,128.51) ; v1(162.08,120.61) 161.81,120.61 161.51,120.91 UV15.A3 ; UV1.R27 125.11,141.8 125.51,142.19 126.15,142.19 UV1.N27 ; UV13.T5 v1(149.1,139.94) ; UV1.AD32 v1(117.74,144.82) ; UV15.B10 v1(160.33,126.13) ; v1(131.39,134.64) 132.1,134.64 UV1.F18 ; UV13.R14 150.31,147.09 v1(150.16,147.24) ; UV15.C14 159.91,130.05 v1(160.18,130.33) ; v1(157.91,147.13) 158.31,146.73 UV13.E14 ; UV13.C3 159.91,137.93 v1(160.31,138.33) 159.91,138.73 UV13.C4 ; UT1.12 v1(29,119.81) ; UV15.A14 161.51,129.76 v1(161.17,130.1) ; v1(156.71,140.09) 156.71,140.09 UV13.G5 ; UC1.CB33 116.21,55.23 v1(117.26,55.23) 117.56,54.93 UC1.CC31 ; v1(112.71,141.77) 112.41,141.77 v1(110.59,139.95) ; UV15.E3 v1(157.91,120.51) ; UV1.AE27 v1(117.33,141.4) ; UV13.A3 161.51,137.93 161.12,138.32 v1(161.12,138.33) ; UV15.B5 v1(161.14,122.08) ; UC1.B9 131.54,92.16 v1(131.02,91.65) ; v1(131.73,130.99) UV1.F14 ; UC1.AG5 v1(134.19,76.26) ; UV15.H1 v1(155.91,118.74) ; v1(161.91,135.93) 161.51,136.33 UV13.A1 ; UV1.F2 132.13,122.99 132.13,121.99 v1(132.15,121.99) ; v1(160.31,139.93) 160.71,139.53 UV13.B5 ; UV13.A14 161.51,146.73 161.12,147.12 v1(161.12,147.13) ; UV1.J27 v1(129.74,142.45) ; UV1.AC24 UV1.AD25 117.74,140.26 v1(117.39,140.61) ; UV15.U12 v1(149.11,127.71) ; UC1.CR6 133.46,47.76 133.03,47.33 v1(132.98,47.33) ; v1(149.92,119.69) 150.3,119.31 UV15.R1 ; UV15.U14 v1(148.24,130.17) ; v1(150.71,144.73) UV13.R12 ; UV15.U3 v1(148.29,120.49)
  BOTTOM w0.3: UV1.V32 123.17,144.2 v1(123.57,144.59) ; v1(132.58,129.34) 132.14,129.78 UV1.F12 ; UV1.F24 132.51,139.42 v1(132.63,139.31) ; v1(129.37,124.61) 129.33,124.61 UV1.K6 ; UV1.AH10 114.79,128.45 v1(114.79,128.7)
  BOTTOM w0.305: JSSD1.27 32.87,33.19 32.54,32.85 v1(32.52,32.85) ; v1(213.27,54.35) 213.17,54.45 JEDP1.13 ; JSSD1.33 31.38,33.31 31.44,33.24 31.44,33.22 31.82,32.84 v1(31.89,32.84) ; UV1.AG12 114.79,129.25 v1(114.79,128.7) ; v1(132.41,133.4) 132.14,133.13 UV1.F16 ; v1(119.01,140.72) 118.82,140.72 UV1.AC26 ; JFP1.4 219.52,29.56 v1(219.55,29.52) 219.71,29.52 220.02,29.83 JFP1.3 ; UV1.R27 124.94,142.1 v1(124.63,142.41) ; v1(76.36,122.93) 76.77,123.34 77.85,123.34 78.16,123.65 JWLAN1.13 ; v1(30.07,35.12) 29.87,34.93 JSSD1.39 ; v1(213.31,52.52) 213.21,52.52 213.14,52.45 JEDP1.17 ; JDIMM1.106 69.95,83.74 69.63,84.06 v1(69.63,84.16) ; UV1.AB24 120.17,140.03 v1(120.17,140.85) ; JEDP1.32 213.47,44.95 v1(213.63,44.79) ; v1(187.49,36.69) 187.2,36.4 JHDD1.7 ; v1(116.88,131) 116.94,131.05 UV1.AE14 ; UV1.AG27 115.3,141.8 ; 115.3,141.8 v1(114.95,141.44) ; 115.3,141.8 115.3,141.83 UV1.AH28 ; UV1.W26 122.27,141 v1(122.54,141.27) ; JEDP1.35 213.26,43.45 v1(213.39,43.58) ; UV1.K11 129.31,128.82 v1(129.31,128.69) ; UV1.T25 124.12,140.2 123.68,140.64 v1(123.61,140.64) 123.17,140.2 UV1.U25 ; UV1.U9 123.1,127.4 v1(122.67,126.96) ; UV1.K22 129.39,138.05 v1(129.39,138.07) ; JSSD1.45 28.38,35.15 v1(28.29,35.24) ; v1(45.69,98.48) 45.58,98.37 JESPI1.9 ; 80.68,125.15 80.67,125.15 JWLAN1.19 ; v1(188.12,36.69) 188.7,36.1 JHDD1.4 ; JSSD1.21 34.38,32.19 v1(33.77,31.58) ; JHDD1.1 190.2,36.13 189.62,36.71 v1(189.48,36.71) ; JSSD1.51 26.87,34.93 27.16,35.21 v1(27.16,35.37) ; v1(26.39,36.25) 26.06,36.25 25.38,35.57 JSSD1.57 ; JDIMM1.243 77.75,47.49 v1(77.72,47.52) ; UV1.Y25 120.96,140.2 v1(121.41,140.65) 121.86,140.2 UV1.W25 ; UV1.Y32 121.38,144.64 v1(121.71,144.64) ; JEDP1.38 213.09,41.95 213.1,41.95 213.5,41.95 213.5,41.95 v1(213.78,41.95) ; JFP1.1 221.02,30.99 221.18,31.15 v1(221.53,31.15) ; v1(130.21,126.21) 129.8,125.8 UV1.J7 UV1.H6 ; UV1.U27 123.55,141.59 123.55,141.4 v1(123.61,141.34) ; JEDP1.20 213.3,50.95 v1(213.39,50.86) ; v1(70.28,125.12) 70.49,124.9 JWLAN1.18 ; v1(121.37,142.18) 121.74,141.81 UV1.W27 ; UV1.AC27 118.29,142.05 118.21,142.05 v1(118.14,142.11) ; v1(118.16,127.77) UV1.AC9 ; v1(67.98,84.16) 67.98,83.84 67.62,83.49 JDIMM2.107
  BOTTOM w0.356: CV158.2 v1(164.88,135.67) ; CV155.2 v1(164.85,140.14) ; CV153.2 v1(164.85,139.03) CV160.2 ; v1(137.5,117.92) 137.17,117.59 CZ24.2 ; CZ2.2 v1(128.05,109.96) ; RV55.2 155.23,149.59 CV151.2 ; CV172.2 156.11,132.67 155.86,132.92 RV51.2 ; v1(107.48,119.95) 107.48,119.94 107.98,119.94 108.1,120.06 UV2.3 ; CC6.2 v1(110.45,61.27) ; CZ3.2 130.84,106.66 CZ1.2 ; CV181.2 v1(165.34,130.11) ; CV157.2 v1(164.88,137.86)
  BOTTOM w0.381: CV182.2 v1(165.64,124.7) ; v1(124.86,127.25) 125.01,127.4 UV1.P9 ; CU13.2 19.76,51.53 v1(19.97,51.75) ; v1(221.51,35.15) 221.49,35.18 EU5.1 ; CV183.2 v1(165.64,126.86) ; v1(202.31,40.28) 202.73,40.69 PCB19.2 ; CV191.2 v1(165.63,119.69) ; CV188.2 v1(165.63,122.74) ; v1(165.21,118.03) 164.94,118.3 CV164.2 ; UV1.P25 125.63,140.2 v1(126.15,140.72) 126.67,140.2 UV1.N25 ; EU6.1 223.23,35.81 v1(223.4,35.99) ; UV1.H20 130.07,136.87 130.07,136.91 v1(130.08,136.91) ; v1(121.79,136.25) UV1.Y20 ; v1(118.22,133.43) 118.25,133.47 118.25,133.71 UV1.AC17 ; v1(130.55,43.03) 130.7,43.03 131.17,42.56 131.17,42.43 131.56,42.05 CC79.1 131.79,42.18 131.79,43.51 131.91,43.64 RE22.2 ; CV184.2 v1(165.64,127.94) ; CV190.2 v1(165.63,120.71) ; UV1.V11 v1(122.78,129.44) ; CV189.2 v1(165.63,121.72) ; U3.5 v1(177.44,63.73) ; ED2.1 v1(210.54,39.64)
  BOTTOM w0.4: UV1.A3 135.09,123.17 v1(135.1,123.17)
  BOTTOM w0.406: JESPI1.12 v1(42.95,99.87) ; v1(27.47,128.07) 27.71,128.31 Q16.1 ; v1(30.9,129.98) 30.53,129.61 Q16.4 ; v1(42.04,92.77) JESPI1.11
  BOTTOM w0.457: RC55.2 123.94,42.43 123.97,42.46 124.44,42.46 v1(124.48,42.49)
  BOTTOM w0.508: JTP1.5 v1(121.05,31.68) ; v1(141.26,49.79) 141.19,49.79 141.13,49.84 140.57,49.84 RC83.2 ; JODD1.26 183.2,65.55 184.59,65.55 v1(185.01,65.97) ; v1(196.81,65.65) 196.95,65.8 JODD1.25 ; PHV01.2 89.41,121.7 v1(89.62,121.91) ; v1(206.41,35.8) 206.2,36.01 JIOB1.8 ; PCI05.2 PCI08.2 v1(169.4,70.86) ; PCI126.2 157.96,75.62 v1(157.96,76) ; PC12.2 176.89,34.72 PBATT1.11 v1(176.11,33.21) ; JIOB1.17 215.05,33.75 v1(214.37,34.43) ; v1(119.72,35.74) 119.39,36.06 CC5.1 ; v1(108.14,129.58) 108.14,129.05 108.02,128.94 RV88.1 ; CZ33.1 CZ30.2 CZ32.1 119.67,106.36 120.18,105.85 v1(120.56,105.85) ; PCI123.2 157.96,78.04 v1(157.96,78.42) ; JPWR1.6 226.84,66.4 226.33,65.89 225.61,65.89 v1(225.59,65.91) ; v1(132.37,105.09) CZ4.2 131.17,105.39 131.61,105.82 RC11.1 ; RC63.2 v1(117.94,42.48) ; JIOB1.18 195.03,33.75 194.02,32.73 v1(193.65,32.73) ; PCB04.2 v1(198.28,48.57) ; JFP1.9 v1(215.37,25.66) ; JKB1.31 v1(58.27,28.75) ; EU4.1 28.99,39.3 v1(29.63,38.67) ; v1(127.42,109.96) 126.86,109.41 CZ5.2 ; v1(217.46,62.8) 216.81,62.15 JEDP1.42 ; JSPK1.6 v1(16.71,2.01) ; PHZ05.2 158.11,97.39 v1(158.13,97.4) 158.4,97.4 158.64,97.65 PCG10.2 ; v1(157.96,71.18) 157.96,70.8 PCI120.2 ; CV96.2 v1(150.94,117.33) ; v1(108.62,138.11) RV4.2 RV163.2 ; v1(159.11,133.18) 158.85,132.92 RV121.2 ; v1(211.18,45.9) 210.85,46.24 PCB11.2 210.52,46.22 PCB12.2 ; JPWR1.5 218.64,66.84 219.05,67.24 v1(219.68,67.24) ; PCI108.2 155.42,70.8 v1(155.42,71.18) ; v1(134.38,31.25) 134.96,31.25 136.05,32.34 136.05,33.02 ; v1(181.45,36.69) 181.97,36.69 182.41,36.25 CS29.2 ; v1(211.68,35.81) 212.2,36.33 JIOB1.2 ; v1(122.26,38.6) 121.69,39.16 RC116.1 ; PBATT1.12 151.79,34.6 v1(150.91,34.6) ; v1(126.56,29.44) 128.05,27.95 JTP1.10 ; RV134.2 156.3,134.32 v1(155.6,135.02) ; PCB10.2 208.56,48.19 v1(208.14,48.19) ; RT9.2 25.1,115.5 24.98,115.37 v1(24.62,115.37) ; CS30.2 182.79,37.22 v1(182.79,38.22) ; PJPDC1.8 89.3,149.14 v1(89.57,149.41) ; PR308.2 19.76,46.98 PR303.2 v1(19.01,47.77) ; PRB16.2 PRB17.1 v1(203.36,51.11) ; C26.2 113.14,27.16 113.42,27.45 JTP1.9 118.8,27.45 119.34,27.99 v1(119.34,28.09) ; RV117.2 152.88,114.98 v1(151.93,114.98) ; v1(123.72,117.34) 123.92,117.54 RV21.1 ; v1(201.46,51.94) PCB71.2 201.8,51.05 PCB07.2 ; v1(192.91,32.73) 192.16,31.98 JHDD1.13 ; v1(108.62,143.32) 109.33,144.03 CV17.2 ; PCZ34.2 v1(171.23,51.24) ; v1(96.3,32.57) 96.74,32.57 97.25,32.06 JKBBL1.5 ; v1(117.79,37.81) 118.04,37.81 CC4.2 ; v1(199.04,40.95) 199.04,41.59 199.3,41.84 PRB28.1 ; YV1.4 106.66,142.88 v1(107.1,143.31) ; PCA04.2 161.07,59.11 v1(161.45,59.49) ; CC74.2 v1(131.48,26.14) ; PCH11.2 v1(166.09,42.73) ; RC187.1 v1(113.57,32.49) ; PCZ02.2 183.18,56.45 v1(182.81,56.82) ; RV51.2 154.79,132.92 v1(154.5,133.21) ; JSPK1.5 v1(13.2,2.01) ; RV89.1 v1(111.46,128.33) ; JSSD1.76 19.78,30.34 v1(19.59,30.16) ; CZ28.2 134.18,114.86 v1(134.4,114.86) ; RC201.2 RC108.1 123.48,43.67 123.18,43.37 v1(123.18,43.02) ; JODD1.13 191.2,64.84 190.83,65.21 v1(190.83,65.98) 190.83,66.36 191.2,66.73 JODD1.14 ; C22.2 96.54,36.22 v1(96.54,36.62) ; PCW11.2 144.31,112.36 PRW04.2 v1(145.78,112.36) ; v1(156.63,76) 156.63,75.62 PCI119.2 ; v1(170.93,61.24) PCZ30.2 171.69,62 PRZ55.2 ; PRB23.2 PCB09.2 207.8,50.43 v1(207.28,50.95) ; RV38.2 148.53,115.36 v1(148.15,114.98) 148.1,115.03 148.09,115.03 147.87,115.25 147.87,115.26 147.64,115.49 CV97.2 ; CV18.2 110.19,139.56 v1(110.59,139.95) ; JODD1.2 184.88,67.62 v1(184.24,67.62) ; v1(15.53,117.66) 15.27,117.91 EU7.1 ; v1(142.22,89.86) 142.27,89.81 RC141.1 RC143.1 RC142.1 ; v1(133.77,113.22) 133.77,113.33 134.68,114.25 134.96,114.25 CZ26.2 ; CZ36.1 CZ35.1 119.97,113.93 v1(120.56,113.34) ; v1(100.67,36.69) 101.06,36.3 101.06,34.09 100.38,33.41 Q6.3 ; v1(128.05,109.96) 128.32,110.23 v3(128.32,110.69) 128.44,110.82 130.54,110.82 131.15,110.21 CC76.2 ; v1(218.03,39.43) 217.85,39.25 JEDP1.41 ; RC119.2 v1(121.95,40.88) ; UC3.4 129.23,33.59 129.23,32.99 v1(129.26,32.96) ; PCB05.2 v1(198.28,46.1) ; CV173.2 v1(163.04,132.33) ; RC137.1 RC138.1 142.91,84.15 v1(142.91,85.53) ; v1(156.63,78.42) 156.63,78.04 PCI129.2 ; PR511.2 PC516.2 PR508.2 24.72,91.5 v1(24.55,91.32) ; UZ5.9 134.41,116.91 v1(134.89,117.39) ; v1(167.23,44.64) 167.05,44.46 PRH09.2 ; v1(119.19,119.82) 119.19,118.96 119.55,118.6 RV83.2 ; v1(139.28,112.9) PRW02.2 PCW09.2 ; RC66.1 v1(110.22,58.61) ; CZ6.2 123.35,107.25 v1(122.84,106.74) 123.35,106.23 CZ7.2 ; RV55.2 155.56,150.61 v1(155.53,150.64) ; JODD1.1 v1(185.2,62.82) ; JFP1.10 v1(221.22,27.47) ; JPWR1.1 221.24,62.76 v1(221.78,62.23) ; RV123.2 156.4,150.57 v1(156.43,150.6) ; CT20.2 v1(27.21,113.65) ; JODD1.8 v1(188.2,66.12) JODD1.7 ; EU11.1 v1(12.23,125.15) ; PCI103.2 154.15,70.8 v1(154.15,71.18) ; v1(180.25,74.23) 180.77,73.7 JFAN1.4 ; v1(139.86,65.46) 139.48,65.84 CC19.2 141.14,66.1 CC71.2 ; JIOB1.10 v1(204.2,35.8) ; v1(129.71,117.13) 130.23,117.13 CZ27.2 ; JKB1.32 84.43,30.92 84.93,31.43 v1(85.18,31.43) ; JFAN1.6 177.6,68.47 v1(177.39,68.26) ; RV119.2 165.03,123.62 v1(165.63,123.62) ; v1(29.35,91.04) 28.25,92.15 28.09,92.15 27.34,92.9 PC2506.2 ; UU1.2 v1(19.97,51.75) ; C21.2 15.83,131.88 v1(15.35,131.88) ; C28.2 183.55,61.33 183.65,61.43 v1(183.87,61.43) ; PCW10.2 141.69,111.44 PRW10.2 141.69,112.8 v1(141.6,112.89) ; v1(126.97,117.79) RV151.2 RV152.1 ; RI16.2 v1(14.89,108.26) ; CZ25.1 v1(138.34,115.95) ; PCA118.2 v1(153.2,57.15) ; CL21.2 v1(27.38,71.19) ; v1(26.58,132.52) 27.09,132.01 RC158.2 ; v1(127.26,103.81) 127.26,103.82 126.75,104.33 CZ8.2 ; v1(169.83,86.93) 169.49,86.93 PCI30.2 ; PC5.2 v1(94.01,150.3) ; JFAN1.5 v1(178.88,75) ; PRZ64.2 v1(170.34,52.31) ; v1(131.78,106.99) CZ3.2 ; PCZ23.2 v1(172.63,47.84) ; v1(91.78,35.25) 91.78,35.75 R40.2 ; PCI125.2 156.69,70.8 v1(156.69,71.18) ; PC6.2 95.67,149.73 v1(95.09,150.3) ; v1(209.2,35.7) JIOB1.5
  vias: v1(1.63,126.87) v1(1.93,105.52) v1(3.42,88.67) v1(4.64,112.6) v1(4.74,130.5) v1(4.93,42.63) v1(5.06,133.67) v1(5.55,65.5) v1(5.8,132.33) v1(5.8,128.67) v1(5.77,114.56) v1(5.77,110.64) v1(5.89,41.2) v1(6.52,118.19) v1(6.89,124.43) v1(6.95,43.03) v1(6.95,39.37) v1(7.76,82.41) v1(7.9,132.33) v1(7.9,128.67) v1(8.03,114.56) v1(8.03,110.64) v1(8.96,130.5) v1(9.11,118.23) v1(9.05,43.03) v1(9.05,39.37) v1(9.18,125.8) v1(9.24,116.89) v1(9.16,112.6) v1(9.54,105.03) v1(9.7,36.43) v1(9.78,22.07) v1(10.11,41.2) v1(10.28,124.83) v1(10.65,63.71) v1(10.94,89.86) v1(10.93,1.86) v1(11.15,60.33) v1(11.65,45.97) v1(12.4,41.56) v1(12.4,40.8) v1(12.4,40.04) v1(12.4,38.92) v1(12.54,120.2) v1(12.68,133.67) v1(13.12,119.63) v1(13.85,43.54) v1(13.85,42.91) v1(13.85,42.32) v1(13.85,41.71) v1(13.93,30.09) v1(13.93,24.09) v1(14.44,43.57) v1(14.44,42.93) v1(14.44,42.31) v1(14.45,41.71) v1(14.43,22.93) v1(18.18,97.06) v1(18.18,95.26) v1(18.18,93.07) v1(18.18,91.27) v1(18.18,89.34) v1(18.42,0.43) v1(19.08,118.68) v1(19.21,120.58) v1(19.85,27.43) v1(19.85,26.79) v1(20.3,133.67) v1(20.48,27.43) v1(20.48,26.79) v1(20.61,60.64) v1(20.61,60) v1(20.74,90.99) v1(20.99,91.63) v1(21.18,60.32) v1(21.75,93.15) v1(21.87,89.83) v1(22.01,53.14) v1(22.01,52.38) v1(22.17,122.93) v1(22.26,94.42) v1(22.26,43.65) v1(22.51,96.71) v1(22.51,31.81) v1(22.58,95.56) v1(22.96,97.09) v1(23.02,55.43) v1(23.11,122.93) v1(23.08,83.38) v1(23.08,82.26) v1(23.08,81.14) v1(23.58,104.25) v1(23.72,54.86) v1(23.72,54.22) v1(23.72,53.59) v1(23.72,52.95) v1(24.18,105.9) v1(24.21,104.25) v1(24.2,83.38) v1(24.2,82.26) v1(24.2,81.14) v1(24.81,105.9) v1(24.8,104.25) v1(24.8,77.4) v1(25.31,83.38) v1(25.31,82.26) v1(25.31,81.14) v1(25.31,76.64) v1(25.45,105.9) v1(25.56,97.17) v1(26.04,0.43) v1(26.08,105.9) v1(26.69,76.89) v1(27.47,85.53) v1(27.72,78.23) v1(27.78,6.47) v1(27.92,133.67) v1(28.23,124.2) v1(28.44,96.55) v1(28.44,95.91) v1(28.44,95.28) v1(28.44,94.64) v1(28.44,94.01) v1(28.48,123.38) v1(28.61,58.86) v1(28.6,51.54) v1(28.69,117.98) v1(28.69,116.84) v1(28.92,84.76) v1(29.02,96.55) v1(29.02,95.91) v1(29.02,95.28) v1(29.02,94.64) v1(29.02,94.01) v1(29.04,51.11) v1(28.99,6.47) v1(29.49,37.01) v1(29.6,96.55) v1(29.6,95.91) v1(29.6,95.28) v1(29.6,94.64) v1(29.6,94.01) v1(29.75,117.98) v1(29.75,116.84) v1(29.88,49.84) v1(30.08,14.59) v1(30.08,13.01) v1(30.08,11.44) v1(30.16,96.75) v1(30.16,96.12) v1(30.16,95.48) v1(30.16,94.85) v1(30.16,94.21) v1(30.7,111.18) v1(30.7,110.55) v1(30.82,117.98) v1(30.82,116.84) v1(30.9,58.35) v1(31.34,111.18) v1(31.34,110.55) v1(31.4,49.53) v1(31.66,14.59) v1(31.66,13.01) v1(31.66,11.44) v1(31.78,38.67) v1(31.78,36.25) v1(31.78,4.69) v1(31.97,111.18) v1(31.97,110.55) v1(32.23,5.14) v1(32.42,36.25) v1(33.23,14.59) v1(33.23,13.01) v1(33.23,11.44) v1(33.44,40.44) v1(33.66,0.43) v1(34.01,5.01) v1(34.18,38.4) v1(34.51,5.65) v1(35.09,40.83) v1(35.54,133.67) v1(35.98,39.17) v1(36.22,28.81) v1(36.85,29.43) v1(36.85,28.19) v1(37.05,16.51) v1(37.05,15.92) v1(37.47,28.81) v1(37.88,39.17) v1(38.53,25.33) v1(38.52,24.7) v1(38.71,8.63) v1(38.9,58.03) v1(39.28,14.79) v1(39.28,14.16) v1(39.28,13.52) v1(39.28,12.89) v1(39.59,43.43) v1(39.72,23.31) v1(40.08,88.26) v1(40.31,23.31) v1(40.37,4.03) v1(40.77,19.26) v1(40.77,11.64) v1(40.89,23.31) v1(41.47,23.31) v1(41.56,33.33) v1(41.56,32.63) v1(41.93,137.82) v1(42.06,23.31) v1(42.17,29.93) v1(42.64,23.31) v1(42.78,29.93) v1(43.23,23.31) v1(43.29,129.9) v1(43.34,56.89) v1(43.34,56.13) v1(43.72,36.13) v1(44.04,112.14) v1(44.4,131.81) v1(44.39,127.99) v1(44.48,86.36) v1(44.7,24.53) v1(45.28,24.53) v1(45.37,112.2) v1(45.87,24.53) v1(46.45,24.53) v1(46.61,131.81) v1(46.6,127.99) v1(47.02,108.77) v1(47.02,108.14) v1(47.04,24.53) v1(47.45,22.93) v1(47.71,129.9) v1(48.34,102.67) v1(48.68,141.37) v1(48.92,32.56) v1(49.44,45.14) v1(49.5,32.56) v1(49.56,101.91) v1(50.07,46.45) v1(50.08,32.56) v1(50.67,32.56) v1(51.25,32.56) v1(53.01,44.24) v1(53.12,42.44) v1(55.07,22.93) v1(55.91,106.1) v1(56.3,141.37) v1(56.32,108.9) v1(56.75,103.46) v1(56.75,102.06) v1(56.75,100.66) v1(56.83,99.24) v1(56.84,98.24) v1(56.84,91.29) v1(56.82,88.12) v1(56.8,51.11) v1(56.89,94.59) v1(56.93,93.24) v1(56.92,89.74) v1(56.92,86.83) v1(56.92,83.85) v1(56.93,54.92) v1(56.85,50.48) v1(56.98,63.24) v1(56.98,62.24) v1(56.98,61.24) v1(56.98,59.24) v1(56.98,57.74) v1(56.98,49.74) v1(56.99,48.7) v1(56.96,46.36) v1(58.12,26.93) v1(59.52,52.74) v1(59.67,107.12) v1(59.9,26.55) v1(59.98,72.34) v1(60.05,69.06) v1(60.07,84.09) v1(60.35,91.17) v1(60.43,102.07) v1(60.37,57.97) v1(60.37,47.45) v1(60.55,74.78) v1(60.75,105.93) v1(60.81,108.89) v1(60.81,103.46) v1(60.81,100.73) v1(60.81,98.15) v1(60.81,95.48) v1(60.81,92.57) v1(60.81,89.27) v1(60.81,79.29) v1(60.81,66.8) v1(60.75,64.95) v1(60.75,61.64) v1(60.75,59.61) v1(60.75,56.63) v1(60.75,54.66) v1(60.75,50.88) v1(60.75,49.24) v1(60.75,46.19) v1(60.86,118.87) v1(61.32,80.56) v1(61.51,72.34) v1(61.59,84.09) v1(61.57,82.23) v1(61.55,76.8) v1(61.57,70.78) v1(61.57,69.06) v1(61.7,86.01) v1(61.9,107.26) v1(61.9,63.37) v1(61.9,52.25) v1(62.02,128.97) v1(61.95,96.75) v1(62,31.4) v1(62.33,108.89) v1(62.27,105.93) v1(62.33,103.46) v1(62.33,100.73) v1(62.33,98.15) v1(62.33,95.48) v1(62.33,92.57) v1(62.33,89.27) v1(62.33,79.29) v1(62.33,66.8) v1(62.28,64.95) v1(62.28,61.64) v1(62.28,59.61) v1(62.28,56.63) v1(62.28,54.66) v1(62.28,50.88) v1(62.28,49.24) v1(62.28,46.19) v1(62.33,30.92) v1(62.61,118.87) v1(62.71,102.07) v1(62.7,91.17) v1(62.66,57.97) v1(62.66,47.45) v1(62.69,22.93) v1(62.84,80.56) v1(62.84,74.78) v1(63.03,72.34) v1(63.12,84.09) v1(63.09,82.23) v1(63.09,79.29) v1(63.08,76.8) v1(63.09,70.78) v1(63.09,69.06) v1(63.22,86.01) v1(63.8,105.93) v1(63.8,64.95) v1(63.8,61.64) v1(63.8,59.61) v1(63.8,56.63) v1(63.8,54.66) v1(63.8,50.88) v1(63.8,49.24) v1(63.8,46.19) v1(63.92,141.37) v1(63.86,108.89) v1(63.86,103.46) v1(63.86,100.73) v1(63.86,98.15) v1(63.86,95.48) v1(63.86,92.57) v1(63.86,89.27) v1(63.86,66.8) v1(64.19,107.26) v1(64.24,96.75) v1(64.18,63.37) v1(64.18,52.25) v1(64.36,118.8) v1(64.36,80.56) v1(64.64,84.09) v1(64.62,79.29) v1(64.62,69.06) v1(64.68,128.46) v1(64.74,86.01) v1(64.78,125.3) v1(64.8,91.17) v1(66.58,32.25) v1(67.22,32.25) v1(67.74,95.19) v1(67.73,92.57) v1(67.75,87.54) v1(67.73,59.92) v1(67.68,56.81) v1(67.73,54.21) v1(67.73,52.75) v1(67.66,46.22) v1(67.8,103.16) v1(67.84,98.15) v1(67.8,96.75) v1(67.78,85.66) v1(67.84,49.02) v1(67.85,107.26) v1(67.91,105.93) v1(67.9,65.08) v1(67.96,89.27) v1(68.11,136.46) v1(68.11,110.42) v1(69,51.04) v1(69.25,110.42) v1(69.44,102.04) v1(69.38,49.02) v1(69.49,105.93) v1(69.46,103.17) v1(69.5,98.15) v1(69.5,87.54) v1(69.5,59.9) v1(69.59,95.48) v1(69.63,92.57) v1(69.63,58.11) v1(69.63,56.79) v1(69.67,89.27) v1(69.71,54.21) v1(69.73,51.04) v1(69.65,46.27) v1(70.31,22.93) v1(71.38,142.89) v1(72.31,63.77) v1(72.65,131.22) v1(72.65,129.7) v1(72.65,128.18) v1(72.71,84.16) v1(72.75,81.64) v1(72.75,79.95) v1(72.68,72.3) v1(72.75,69.06) v1(72.87,85.66) v1(73.05,91.28) v1(73.07,102.02) v1(73.07,58.14) v1(73.07,47.52) v1(73.2,51.01) v1(73.32,103.22) v1(73.35,61.77) v1(73.51,100.73) v1(73.51,95.48) v1(73.51,92.57) v1(73.51,89.27) v1(73.49,76.39) v1(73.45,64.95) v1(73.45,59.93) v1(73.45,56.82) v1(73.45,54.19) v1(73.45,49.02) v1(73.45,46.27) v1(73.59,105.93) v1(73.56,98.15) v1(73.57,74.02) v1(73.71,109.17) v1(74.18,131.22) v1(74.18,129.7) v1(74.18,128.18) v1(74.23,84.16) v1(74.21,72.3) v1(74.27,81.64) v1(74.27,79.95) v1(74.27,78.26) v1(74.27,69.06) v1(74.4,85.66) v1(74.6,63.65) v1(74.6,52.75) v1(74.67,107.23) v1(74.65,96.75) v1(74.84,103.22) v1(74.79,51.04) v1(74.87,61.77) v1(75.03,100.73) v1(75.03,95.48) v1(75.03,92.57) v1(75.03,89.27) v1(75.01,76.39) v1(74.98,64.95) v1(74.98,59.93) v1(74.98,56.82) v1(74.98,54.19) v1(74.98,49.02) v1(74.98,46.27) v1(75.11,105.93) v1(75.09,98.15) v1(75.23,109.17) v1(75.35,137.03) v1(75.34,91.28) v1(75.36,102.02) v1(75.36,47.52) v1(75.47,119.74) v1(75.47,74.02) v1(75.7,131.22) v1(75.7,129.7) v1(75.7,128.18) v1(75.73,72.3) v1(75.76,84.16) v1(75.79,81.64) v1(75.79,79.95) v1(75.79,78.26) v1(75.78,76.39) v1(75.79,70.67) v1(75.79,69.06) v1(75.79,66.89) v1(75.92,85.66) v1(76.11,137.98) v1(76.34,117.01) v1(76.31,51.04) v1(76.37,103.22) v1(76.4,61.77) v1(76.5,64.95) v1(76.5,59.93) v1(76.5,56.82) v1(76.5,54.19) v1(76.5,49.02) v1(76.5,46.27) v1(76.62,135.06) v1(76.64,105.93) v1(76.56,100.73) v1(76.61,98.15) v1(76.56,95.48) v1(76.56,92.57) v1(76.56,89.27) v1(76.76,109.17) v1(76.94,96.75) v1(76.88,63.65) v1(76.88,52.75) v1(76.95,107.23) v1(77.28,84.16) v1(77.3,76.39) v1(77.32,66.89) v1(77.45,85.66) v1(77.38,74.02) v1(77.63,120.9) v1(77.76,137.47) v1(77.93,22.93) v1(78.09,117.06) v1(79.16,117.09) v1(79.78,150.47) v1(80.43,109.17) v1(80.43,105.96) v1(80.39,92.57) v1(80.43,61.77) v1(80.43,58.14) v1(80.43,49.02) v1(80.47,103.19) v1(80.46,89.27) v1(80.54,84.16) v1(80.45,74.02) v1(80.53,54.2) v1(80.65,98.15) v1(80.57,95.48) v1(80.55,56.82) v1(80.55,52.75) v1(80.68,138.87) v1(80.68,138.17) v1(80.68,137.35) v1(80.68,136.58) v1(80.69,133.56) v1(80.74,127.88) v1(80.69,100.73) v1(81.03,74.02) v1(81.06,117.03) v1(81.44,142.43) v1(81.44,141.41) v1(81.44,140.39) v1(81.44,127.39) v1(81.62,74.02) v1(81.95,128.9) v1(82.03,127.39) v1(82.2,74.02) v1(82.65,133.35) v1(82.65,127.38) v1(82.75,69.06) v1(84.64,127.24) v1(84.64,126.65) v1(84.65,133.55) v1(84.65,132.79) v1(84.67,130.75) v1(84.67,129.99) v1(84.67,129.23) v1(85.28,130.75) v1(85.28,129.99) v1(85.28,129.23) v1(85.51,37.14) v1(85.51,35.62) v1(85.51,34.09) v1(85.55,22.93) v1(85.89,130.75) v1(85.89,129.99) v1(85.89,129.23) v1(86.5,130.75) v1(86.5,129.99) v1(86.5,129.23) v1(87.03,37.14) v1(87.03,35.62) v1(87.03,34.09) v1(87.11,130.75) v1(87.11,129.99) v1(87.11,129.23) v1(87.11,40.38) v1(87.71,130.75) v1(87.71,129.99) v1(87.71,129.23) v1(87.73,40.38) v1(88.07,32.01) v1(88.17,29.01) v1(88.32,130.75) v1(88.32,129.99) v1(88.32,129.23) v1(88.55,37.14) v1(88.55,35.62) v1(88.55,34.09) v1(88.93,130.75) v1(88.93,129.99) v1(88.93,129.23) v1(89.54,130.75) v1(89.54,129.99) v1(89.54,129.23) v1(90.15,130.75) v1(90.15,129.99) v1(90.15,129.23) v1(90.27,113.49) v1(90.76,130.75) v1(90.76,129.99) v1(90.76,129.23) v1(91.16,59.24) v1(91.37,130.75) v1(91.37,129.99) v1(91.37,129.23) v1(91.54,59.69) v1(91.77,153.97) v1(91.98,130.75) v1(91.98,129.99) v1(91.98,129.23) v1(92.03,113.49) v1(92.59,130.75) v1(92.59,129.99) v1(92.59,129.23) v1(93.2,130.75) v1(93.2,129.99) v1(93.17,22.93) v1(93.38,118.74) v1(93.63,117.16) v1(95.03,56.32) v1(97.7,84.35) v1(98.33,28.38) v1(99.09,84.35) v1(99.61,62.95) v1(100.03,63.36) v1(100.43,143.19) v1(100.43,142.55) v1(100.43,141.92) v1(100.36,45.27) v1(100.49,84.35) v1(100.79,22.93) v1(101.69,144.18) v1(101.89,116.58) v1(101.89,84.35) v1(102.52,116.58) v1(103.16,116.58) v1(103.41,144.71) v1(103.79,116.58) v1(103.85,58.86) v1(104.25,59.73) v1(104.3,60.58) v1(104.43,58.92) v1(105.31,84.38) v1(105.7,79.06) v1(105.71,63.3) v1(105.97,66.54) v1(106.14,86.19) v1(106.19,80.87) v1(106.26,72.84) v1(106.37,83.95) v1(106.71,112.96) v1(106.66,69.87) v1(107.12,147.66) v1(107.13,68.2) v1(107.16,82.57) v1(107.36,80.85) v1(107.54,75.67) v1(107.48,63.64) v1(107.83,87.99) v1(108.16,72.84) v1(108.35,23.88) v1(108.43,66.54) v1(108.51,91.91) v1(108.53,80.67) v1(108.49,77.09) v1(108.5,71.14) v1(108.6,153.97) v1(108.62,112.96) v1(108.56,89.3) v1(108.56,69.87) v1(108.73,84.26) v1(108.75,86.69) v1(108.76,64.9) v1(108.88,79.06) v1(108.98,82.55) v1(109.09,68.21) v1(109.22,148.14) v1(109.28,90.61) v1(109.38,93.22) v1(109.74,87.99) v1(110.13,82.22) v1(110.14,75.63) v1(110.07,72.84) v1(110.21,66.54) v1(110.41,91.91) v1(110.43,71.17) v1(110.46,89.3) v1(110.47,69.87) v1(110.65,149.46) v1(110.65,148.05) v1(110.76,64.86) v1(111.16,74.14) v1(111.29,93.22) v1(111.43,83.23) v1(112.62,139.89) v1(112.88,126.05) v1(114.52,139.89) v1(114.69,127.54) v1(115.46,148.7) v1(115.48,44.71) v1(115.97,23.88) v1(116.14,155.07) v1(116.96,97.88) v1(116.96,96.79) v1(117.2,148.84) v1(117.41,43.33) v1(117.92,83.52) v1(117.95,44.13) v1(118.14,101.4) v1(118.18,129.77) v1(118.27,99.64) v1(118.39,98.74) v1(118.39,96.84) v1(118.54,148.78) v1(119.03,112.33) v1(119.03,110.55) v1(119.24,76.23) v1(119.8,135.38) v1(119.79,132.48) v1(119.8,98.7) v1(120.03,96.23) v1(120.18,128.2) v1(120.44,148.05) v1(120.67,87.21) v1(120.87,110.49) v1(121.32,125.41) v1(121.28,98.13) v1(121.28,96.23) v1(121.75,134.3) v1(121.76,130.41) v1(121.77,78.51) v1(121.77,77.6) v1(121.77,76.69) v1(121.77,75.78) v1(122.7,98.38) v1(122.7,95.84) v1(122.93,131.52) v1(122.91,67.05) v1(122.97,65.02) v1(123.59,23.88) v1(123.74,136.36) v1(123.76,155.07) v1(123.8,153.05) v1(123.96,93.2) v1(124.05,67.05) v1(124.11,65.02) v1(124.34,97.28) v1(124.34,95.37) v1(124.3,84.39) v1(124.65,133.49) v1(124.61,131.4) v1(124.75,64.88) v1(124.75,62.43) v1(124.9,154.96) v1(124.91,151.13) v1(124.94,126.23) v1(125,73.34) v1(125,72.45) v1(125,71.56) v1(125,70.67) v1(125.19,67.05) v1(125.51,84.39) v1(125.68,136.39) v1(125.74,130.53) v1(126.02,64.88) v1(126.02,62.43) v1(126.34,67.05) v1(126.64,137.24) v1(126.6,136.36) v1(126.75,132.48) v1(126.65,130.49) v1(126.8,146.27) v1(127,82.14) v1(127.11,154.96) v1(127.12,151.13) v1(127.29,106.61) v1(127.29,64.89) v1(127.29,62.42) v1(127.43,146.27) v1(127.48,67.05) v1(127.58,82.14) v1(128.22,153.05) v1(128.53,62.42) v1(128.62,67.05) v1(128.56,64.89) v1(128.67,132.26) v1(129.46,134.74) v1(129.76,67.05) v1(131.21,23.88) v1(131.37,154.57) v1(133.93,146.99) v1(134.27,106.18) v1(134.55,105.65) v1(134.86,106.18) v1(135.04,27.11) v1(135.14,105.65) v1(135.44,106.18) v1(135.72,105.65) v1(136.03,106.18) v1(136.31,105.65) v1(136.31,96.2) v1(136.62,142.06) v1(136.76,132.52) v1(136.91,130.98) v1(137.42,127.14) v1(137.75,144.42) v1(138.15,96.01) v1(138.55,132.62) v1(138.6,127.12) v1(138.67,131.01) v1(138.85,61.02) v1(138.83,23.88) v1(138.97,155.07) v1(139.13,62.29) v1(139.25,124.91) v1(139.27,57.58) v1(139.44,27.1) v1(139.56,142.46) v1(140.04,55.96) v1(140.5,28.93) v1(140.5,25.27) v1(140.62,52.64) v1(140.75,56.95) v1(140.88,62.29) v1(141,143.43) v1(141,60.96) v1(141.83,69.53) v1(142.02,92.26) v1(142.02,91.63) v1(142.38,62.8) v1(142.6,28.93) v1(142.6,25.27) v1(143.08,69.53) v1(143.25,57.3) v1(143.42,97.72) v1(143.42,97.09) v1(143.42,96.45) v1(143.42,95.82) v1(143.66,27.1) v1(146.45,23.88) v1(146.59,155.07) v1(146.62,36.2) v1(147.1,51.11) v1(147.42,73.78) v1(147.74,74.86) v1(148.32,66.82) v1(148.5,83.82) v1(148.5,83.18) v1(148.5,82.55) v1(148.5,81.91) v1(148.5,71.5) v1(149.51,108.19) v1(149.69,50.41) v1(150.1,108.19) v1(150.28,50.41) v1(150.53,54.73) v1(150.53,52.89) v1(150.75,139.87) v1(150.68,108.19) v1(150.91,50.41) v1(151.44,139.9) v1(151.55,50.41) v1(151.67,125.74) v1(151.8,52.83) v1(151.93,117.45) v1(152.43,52.83) v1(152.5,89.34) v1(152.5,88.73) v1(152.5,88.13) v1(152.5,87.52) v1(152.56,61.53) v1(152.56,60.89) v1(152.56,60.26) v1(152.56,59.62) v1(152.88,108.2) v1(153.11,89.34) v1(153.11,88.73) v1(153.11,88.13) v1(153.11,87.52) v1(153.18,124.38) v1(153.3,126.04) v1(153.37,113.24) v1(153.37,112.66) v1(153.46,108.2) v1(153.7,103.82) v1(153.7,103.18) v1(153.7,102.55) v1(154.07,23.88) v1(154.21,155.07) v1(154.17,126.01) v1(154.47,103.82) v1(154.47,103.18) v1(154.47,102.55) v1(154.47,101.91) v1(155.23,124.38) v1(155.77,125.46) v1(156.22,148.14) v1(157.63,108.2) v1(157.63,107.62) v1(157.64,103.44) v1(157.64,102.67) v1(157.64,101.91) v1(157.71,36.81) v1(158.07,91.67) v1(158.21,108.2) v1(158.21,107.62) v1(158.54,94.03) v1(158.81,64.54) v1(158.92,92.89) v1(158.92,91.33) v1(159.29,48.32) v1(159.29,47.68) v1(159.29,47.05) v1(159.29,46.41) v1(159.29,45.78) v1(159.29,45.14) v1(159.93,48.32) v1(159.93,47.68) v1(159.93,47.05) v1(159.93,46.41) v1(159.93,45.78) v1(159.93,45.14) v1(160.21,92.89) v1(160.21,91.33) v1(160.44,63.88) v1(161.16,80.76) v1(161.16,80.13) v1(161.16,79.54) v1(161.16,78.91) v1(161.51,92.89) v1(161.51,91.33) v1(161.69,23.88) v1(161.81,154.57) v1(161.79,89.78) v1(161.85,89.18) v1(161.86,82.53) v1(161.86,81.94) v1(161.86,81.32) v1(161.86,80.74) v1(161.86,80.12) v1(161.86,79.53) v1(161.86,78.91) v1(162.06,92.03) v1(162.25,62.88) v1(162.27,90.59) v1(162.34,51.05) v1(162.35,89.99) v1(162.44,89.18) v1(162.43,60.81) v1(162.43,60.18) v1(162.43,59.54) v1(162.5,82.53) v1(162.5,81.94) v1(162.5,81.32) v1(162.5,80.74) v1(162.5,80.12) v1(162.5,79.53) v1(162.5,78.91) v1(162.72,65.24) v1(162.66,51.62) v1(162.82,90.39) v1(162.95,86.44) v1(162.95,85.14) v1(162.95,83.85) v1(163.02,89.18) v1(162.98,51.05) v1(163.12,92.12) v1(163.06,89.84) v1(163.08,82.53) v1(163.08,81.94) v1(163.08,81.32) v1(163.08,80.74) v1(163.08,80.12) v1(163.08,79.53) v1(163.13,78.91) v1(163.1,64.09) v1(163.1,62.53) v1(163.07,60.81) v1(163.07,60.18) v1(163.07,59.54) v1(163.29,87.29) v1(163.29,51.62) v1(163.51,90.39) v1(163.64,89.82) v1(163.62,89.19) v1(163.61,51.05) v1(163.7,92.12) v1(163.65,83.3) v1(163.67,82.53) v1(163.67,81.94) v1(163.67,81.32) v1(163.67,80.74) v1(163.67,80.12) v1(163.67,79.53) v1(163.7,60.81) v1(163.7,60.18) v1(163.7,59.54) v1(163.77,78.91) v1(163.93,51.62) v1(164.14,90.39) v1(164.23,89.81) v1(164.21,89.19) v1(164.25,51.05) v1(164.28,92.12) v1(164.34,60.81) v1(164.34,60.18) v1(164.34,59.54) v1(164.39,64.09) v1(164.39,62.53) v1(164.51,86.44) v1(164.51,85.14) v1(164.51,83.85) v1(164.56,51.62) v1(164.72,90.39) v1(164.82,89.82) v1(164.87,92.12) v1(164.88,70.8) v1(164.88,51.05) v1(164.88,37.08) v1(164.97,60.81) v1(164.97,60.18) v1(164.97,59.54) v1(165.2,51.62) v1(165.32,90.75) v1(165.35,90.16) v1(165.52,70.8) v1(165.61,60.81) v1(165.61,60.18) v1(165.61,59.54) v1(165.65,86.82) v1(165.69,64.09) v1(165.69,62.53) v1(165.67,32.62) v1(166.24,63.24) v1(166.21,61.46) v1(166.24,60.81) v1(166.24,60.18) v1(166.24,59.54) v1(166.34,68.64) v1(166.85,61.46) v1(166.88,60.81) v1(166.88,60.18) v1(166.88,59.54) v1(166.91,32.62) v1(166.98,68.64) v1(166.98,62.73) v1(166.98,62.1) v1(167.29,38.67) v1(167.29,38.03) v1(167.48,61.46) v1(167.51,60.81) v1(167.51,60.18) v1(167.51,59.54) v1(167.61,62.1) v1(167.76,102.7) v1(167.77,102.09) v1(167.77,101.45) v1(167.77,100.82) v1(167.93,38.67) v1(167.93,38.03) v1(168.07,53.1) v1(168.06,52.07) v1(168.56,38.67) v1(168.56,38.03) v1(168.74,27.16) v1(169.07,152.24) v1(169.07,144.62) v1(169.2,38.67) v1(169.2,38.03) v1(169.32,137) v1(169.31,23.88) v1(169.8,129.4) v1(169.83,83.85) v1(169.83,83.23) v1(169.83,38.67) v1(169.83,38.03) v1(170.28,121.79) v1(170.47,38.67) v1(170.47,38.03) v1(170.6,43.49) v1(170.6,42.86) v1(170.6,42.22) v1(170.77,114.19) v1(170.82,106.57) v1(171.1,38.67) v1(171.1,38.03) v1(171.48,43.49) v1(171.48,42.86) v1(171.48,42.22) v1(171.73,99) v1(172.22,91.4) v1(173.01,32.82) v1(173.41,57.92) v1(173.41,55.9) v1(173.41,53.88) v1(173.54,33.18) v1(173.62,32.57) v1(173.64,30.03) v1(174.08,84.01) v1(175.43,57.92) v1(175.43,55.9) v1(175.43,53.88) v1(175.37,30.3) v1(176.06,32.51) v1(176.93,23.88) v1(177.45,57.92) v1(177.45,55.9) v1(177.45,53.88) v1(178.4,77.74) v1(180.68,36.69) v1(182.35,29.23) v1(184.37,55.68) v1(184.57,73.26) v1(184.63,55.11) v1(185.84,60.83) v1(187.61,60.83) v1(188.88,60.83) v1(189.97,29.28) v1(190.66,60.83) v1(191.04,69.24) v1(194.53,41.91) v1(194.53,41.27) v1(194.53,40.64) v1(195.17,41.91) v1(195.17,41.27) v1(195.17,40.64) v1(195.8,41.91) v1(195.8,41.27) v1(195.8,40.64) v1(196.44,42.54) v1(196.44,41.91) v1(196.44,41.27) v1(196.88,46.67) v1(196.88,46.03) v1(196.88,45.4) v1(197.59,29.28) v1(197.77,61.3) v1(197.77,60.71) v1(197.77,60.13) v1(198.59,68.19) v1(202.32,55.9) v1(202.32,53.89) v1(202.9,54.89) v1(203.49,55.9) v1(203.49,53.89) v1(203.54,45.52) v1(204.63,46.62) v1(204.63,45.52) v1(204.63,44.43) v1(205.21,29.28) v1(205.34,63.85) v1(205.72,45.52) v1(206.18,67.47) v1(206.4,65.68) v1(206.4,62.02) v1(208.21,33.08) v1(208.44,41.58) v1(208.43,38.79) v1(208.5,65.68) v1(208.5,62.02) v1(209.46,32.49) v1(209.56,63.85) v1(210.43,38.63) v1(212.83,29.25) v1(215.9,54.87) v1(215.93,52.64) v1(216.77,35.98) v1(216.95,50.73) v1(217.33,54.67) v1(217.78,48.97) v1(218.24,23.88) v1(221.34,68.97) v1(221.52,46.29) v1(222.67,67.9) v1(224.11,67.14) v1(224.82,65.34) v1(224.97,42.69) v1(224.97,35.07) v1(224.97,27.45) v1(225.1,53.55) v1(225.33,51.75) v1(225.66,59.83) v1(225.86,50.26) v1(226.07,53.22) v1(226.37,58.15) v1(226.53,61.37) v1(226.59,65.16) v1(227.97,65.2) v1(227.97,57.58) v3(13.48,121.62) v3(22.98,56.52) v3(26.08,81.19) v3(26.77,97.95) v3(36.5,34.34) v3(45.91,25.36) v3(70.94,45.78) v3(78,146.57) v3(82.14,131.69) v3(103.68,84.44) v3(120.82,77.54) v3(140.92,105.61) v3(154.96,105.39) v3(157.21,106.65) v3(159.38,92.06) v3(160.66,45.54) v3(162.49,78.2) v3(165.48,51.07) v3(165.45,50.97) v3(165.91,90.11) v3(167.22,90.32) v3(168.45,60.61) v3(168.64,60.47) v3(170.96,41.04) v3(174.23,54.71) v3(179.59,36.51) v3(195.86,43.25) v3(196.48,40.67) v3(202.64,51.34) v3(202.98,56.19)
