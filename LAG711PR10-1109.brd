# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_MAA0_6: length 42.1
  TOP w0.127: v1(130.03,135.82) 130.03,136.15 130.31,136.44 131.15,136.44 131.32,136.27 131.32,135.78 131.55,135.55 131.88,135.55 131.97,135.45 134.69,135.45 135.16,135.93
  TOP w0.14: v1(153.89,139.94) 153.5,140.33 152.84,140.33 152.69,140.18 152.69,139.63 152.59,139.53 151.99,139.53 151.86,139.66 151.86,140.2 151.73,140.34 150.48,140.34 150.34,140.2 150.34,139.64 150.22,139.53 149.63,139.53 149.5,139.66 149.5,140.19 149.35,140.34 148.93,140.34 148.59,139.99 148.59,138.22 148.45,138.09 148.18,138.09 148.05,138.23 148.05,138.84 147.91,138.98 147.63,138.98 147.49,138.84 147.49,138.23 147.35,138.09 147.07,138.09 146.93,138.23 146.93,138.94 146.79,139.08 146.51,139.08 146.37,138.94 146.37,138.23 146.23,138.09 142.08,138.09 142.02,138.03 139.73,138.03 139.58,137.89 v2(139.58,137.18) 139.58,136.06 139.45,135.93 139.15,135.93 139.01,136.07 139.01,136.91 138.88,137.05 138.6,137.05 138.46,136.91 138.46,136.07 138.32,135.93 138.04,135.93 137.9,136.07 137.9,136.91 137.76,137.05 137.48,137.05 137.34,136.91 137.34,136.07 137.2,135.93 136.92,135.93 136.78,136.07 136.78,136.87 136.64,137.01 136.36,137.01 136.22,136.87 136.22,136.07 136.08,135.93 135.16,135.93
  BOTTOM w0.112: UV13.K5 v1(153.89,139.94)
  BOTTOM w0.127: UV1.J19 129.74,135.53 v1(130.03,135.82)
M_MAA0_7: length 42.9
  TOP w0.102: 135.94,138.13 135.48,137.67 133.54,137.67 132.87,137.01 132.05,137.01 131.85,136.81 v1(131.85,136.59)
  TOP w0.14: 135.94,138.13 136.31,138.49 138.14,138.49 139.13,139.48 v2(139.92,139.48) 140.98,139.48 142.03,140.53 144.03,140.53 144.51,141 147.38,141 148.16,141.78 159.42,141.78 159.6,141.6 159.6,140.65 159.44,140.49 155.64,140.49 155.5,140.36 155.5,139.68 154.93,139.11 v1(154.7,139.11)
  BOTTOM w0.102: UV1.K19 129.07,135.07 129.26,135.07 129.38,135.2 129.38,135.62 129.52,135.75 129.52,136.11 129.34,136.29 129.34,136.72 129.86,137.24 129.89,137.24 129.94,137.29 130.23,137.29 130.44,137.09 130.63,137.09 130.83,137.28 131,137.28 131.2,137.09 131.3,136.99 131.3,136.99 131.51,136.78 131.66,136.78 v1(131.85,136.59)
  BOTTOM w0.112: UV13.K4 v1(154.7,139.11)
M_MAA0_8: length 40.9
  TOP w0.127: 135.91,137.02 134.58,135.68 132.13,135.68 131.87,135.94 v1(131.71,135.94)
  TOP w0.14: v1(154.64,140) 154.84,140 155.02,140.17 155.02,141.15 154.87,141.3 154.59,141.3 154.46,141.16 154.46,140.72 154.32,140.58 154.04,140.58 153.9,140.72 153.9,141.16 153.76,141.3 153.48,141.3 153.34,141.16 153.34,140.72 153.2,140.58 152.92,140.58 152.78,140.72 152.78,141.16 152.64,141.3 152.36,141.3 152.22,141.16 152.22,140.72 152.08,140.58 151.8,140.58 151.66,140.72 151.66,141.16 151.52,141.3 151.24,141.3 151.1,141.16 151.1,140.72 150.96,140.58 150.68,140.58 150.54,140.72 150.54,141.16 150.4,141.3 150.12,141.3 149.98,141.16 149.98,140.72 149.85,140.58 149.57,140.58 149.43,140.72 149.43,141.16 149.29,141.3 148.48,141.3 148.34,141.16 148.34,140.19 148.19,140.04 147.62,140.04 147.48,139.9 147.48,139.62 147.34,139.48 147.06,139.48 146.92,139.62 146.92,139.9 146.78,140.04 146.01,140.04 145.89,139.92 145.89,138.71 145.75,138.57 145.47,138.57 145.33,138.71 145.33,139.9 145.19,140.04 144.91,140.04 144.77,139.9 144.77,138.71 144.63,138.57 144.35,138.57 144.21,138.71 144.21,139.42 144.07,139.56 143.8,139.56 143.68,139.45 143.68,138.65 143.6,138.57 141.88,138.57 141.82,138.51 v2(141.56,138.51) 139.53,138.51 138.54,137.53 136.42,137.53 135.91,137.02
  BOTTOM w0.127: v1(131.71,135.94) 131.58,135.81 131.41,135.81 131.21,136.01 131.21,136.26 UV1.G20 ; v1(154.64,140) UV13.J5
M_MAA1_0: length 40.5
  TOP w0.127: v1(129.11,131.09) 129.11,130.99 129.5,130.6 130.91,130.6 131.94,129.57 131.94,129.42 132.5,128.86 135.51,128.86 135.62,128.75
  TOP w0.14: 135.62,128.75 135.98,128.39 139.23,128.39 142.25,125.37 142.54,125.37 143.58,126.41 143.8,126.41 144.02,126.2 144.02,126 142.92,124.9 142.92,124.7 143.12,124.5 143.31,124.5 144.41,125.6 144.61,125.6 146.82,123.4 v2(149.42,123.4) 153.8,123.4 154.49,124.09 154.49,125.52 v1(154.66,125.69)
  BOTTOM w0.112: UV15.H4 155.92,121.71 156.28,122.07 156.28,122.77 154.66,124.4 v1(154.66,125.69)
  BOTTOM w0.127: UV1.J14 129.62,131.6 129.11,131.1 v1(129.11,131.09)
M_MAA1_1: length 40.6
  TOP w0.127: v1(129.27,132.37) 129.27,131.54 129.39,131.42 130.5,131.42 130.74,131.17 130.74,131.09 132.1,129.74 132.81,129.74 133.47,129.09 136.09,129.09 136.29,128.89
  TOP w0.14: v1(153.73,125.65) 154.25,125.13 154.25,124.3 153.82,123.88 v2(148.18,123.88) 147.02,123.88 143.79,127.1 143.6,127.1 142.6,126.11 142.4,126.11 142.2,126.3 142.2,126.5 143.52,127.82 143.52,128.02 143.28,128.26 143.07,128.26 141.66,126.84 141.46,126.84 139.41,128.89 136.29,128.89
  BOTTOM w0.112: UV15.H5 155.91,122.84 154.44,124.31 154.44,124.65 154.1,124.99 154.1,125.28 v1(153.73,125.65)
  BOTTOM w0.127: UV1.K14 129.27,131.93 v1(129.27,132.37)
M_MAA1_2: length 40.3
  TOP w0.127: 136,126.18 135.49,126.68 134.71,126.68 134.58,126.81 134.58,127.01 134.42,127.17 134.24,127.17 134.08,127.01 134.08,126.81 133.95,126.68 133.7,126.68 133,127.38 132.69,127.38 131.1,128.96 130.82,128.96 130.5,128.64 130.5,128.59 130.31,128.39 129.97,128.39 129.74,128.62 129.74,129.5 v1(129.51,129.73)
  TOP w0.14: 136,126.18 136,125.71 139.27,122.43 139.78,122.43 139.92,122.57 139.92,123.04 140.06,123.18 140.34,123.18 140.48,123.04 140.48,122.57 140.62,122.43 v2(143.3,122.43) 144.68,122.43 145.02,122.09 145.4,122.09 147.41,120.09 153.36,120.09 154.02,120.75 154.02,121.56 156.46,124 156.46,126.68 v1(156.31,126.83)
  BOTTOM w0.112: v1(156.31,126.83) 156.31,126.91 UV15.H11
  BOTTOM w0.127: v1(129.51,129.73) 129.51,129.43 UV1.J11
M_MAA1_3: length 39.2
  TOP w0.127: 136.58,127.76 135.25,127.76 134.39,128.63 132.41,128.63 131.71,129.33 131.71,129.48 131.04,130.15 130.62,130.15 v1(130.15,129.68)
  TOP w0.14: 136.58,127.76 136.58,127.76 139.18,127.76 139.7,127.24 139.7,127.04 139.21,126.56 139.21,126.36 139.41,126.16 139.61,126.16 140.09,126.65 140.29,126.65 140.52,126.42 140.52,126.22 140.03,125.74 140.03,125.54 140.23,125.34 140.42,125.34 140.91,125.83 141.11,125.83 141.3,125.64 141.3,125.44 140.81,124.95 140.81,124.76 141.01,124.56 141.21,124.56 141.69,125.05 141.89,125.05 143.07,123.87 144.14,123.87 144.28,124.01 144.28,124.7 144.42,124.84 144.7,124.84 144.84,124.7 144.84,124.01 144.98,123.87 145.66,123.87 146.62,122.92 148.59,122.92 148.95,122.55 153.67,122.55 154.73,123.62 154.73,125.09 v2(155.18,125.54) 155.66,126.02 v1(155.74,126.02)
  BOTTOM w0.102: UV1.J13 130.15,129.99 v1(130.15,129.68)
  BOTTOM w0.112: v1(155.74,126.02) 155.91,126.19 UV15.H10
M_MAA1_4: length 39.1
  TOP w0.127: 135.58,126.92 135.25,126.92 134.52,127.65 134.52,127.85 134.2,128.17 132.22,128.17 131.16,129.23 130.57,129.23 v1(130.13,128.79)
  TOP w0.14: 135.58,126.92 135.59,126.92 136.24,126.28 136.24,126.14 138.25,124.13 138.45,124.13 138.87,124.55 139.07,124.55 139.26,124.35 139.26,124.16 138.9,123.8 138.9,123.6 139.12,123.38 139.31,123.38 139.93,124 140.2,124 141.3,122.91 144.88,122.91 v2(145.04,122.74) 145.19,122.6 145.58,122.6 147.27,120.9 153.22,120.9 153.67,121.34 153.67,121.55 156.19,124.07 156.19,126.36 155.84,126.71 155.45,126.71 155.33,126.59 155.33,126.4 155.23,126.3 154.76,126.3 154.68,126.39 v1(154.68,126.85)
  BOTTOM w0.127: UV15.K11 154.31,127.22 v1(154.68,126.85) ; UV1.H11 v1(130.13,128.79)
M_MAA1_5: length 38.3
  TOP w0.127: v1(130.92,129.7) 131.01,129.7 132.32,128.4 134.29,128.4 134.75,127.94 134.75,127.75 135.33,127.16 135.68,127.16
  TOP w0.14: v1(155.79,124.37) 155.79,124.05 153.45,121.71 148.68,121.71 148.54,121.85 148.54,122.3 148.4,122.44 148.05,122.44 147.91,122.3 147.91,121.53 147.77,121.39 147.47,121.39 147.35,121.51 147.35,122.31 147.23,122.43 146.42,122.43 145.46,123.39 142.87,123.39 142.58,123.68 142.38,123.68 142.11,123.4 141.91,123.4 141.77,123.54 141.77,123.74 142.05,124.01 142.05,124.21 141.89,124.37 141.7,124.37 141.2,123.87 141.02,123.87 v2(140.3,124.59) 138.84,126.05 138.64,126.05 137.95,125.35 137.75,125.35 137.58,125.53 137.58,125.73 137.94,126.09 137.94,126.29 137.76,126.47 137.51,126.47 137.21,126.17 136.89,126.17 135.9,127.16 135.68,127.16
  BOTTOM w0.102: UV1.G11 131.34,129.28 v1(130.92,129.7)
  BOTTOM w0.112: UV15.K10 154.4,126.51 155.11,125.79 155.11,125.04 v1(155.79,124.37)
M_MAA1_6: length 40.9
  TOP w0.127: v1(129.78,133.42) 130.28,132.91 130.82,132.91 130.96,132.77 132.05,132.77 132.19,132.91 134.29,132.91 135.14,132.06 136.58,132.06
  TOP w0.14: v1(152.24,125.74) 152.24,126.31 151.88,126.68 151.88,127.16 151.29,127.74 151.29,128.37 151.47,128.55 v2(151.47,131.61) 151.47,132.18 151.33,132.32 150.95,132.32 150.81,132.18 150.81,130.77 150.67,130.63 150.39,130.63 150.25,130.77 150.25,132.18 150.11,132.32 149.83,132.32 149.69,132.18 149.69,130.64 149.55,130.5 149.27,130.5 149.13,130.64 149.13,132.17 148.98,132.32 138.88,132.32 138.63,132.06 136.58,132.06
  BOTTOM w0.112: UV15.K5 153.75,123.07 153.11,123.07 152.21,123.97 152.21,125.71 v1(152.24,125.74)
  BOTTOM w0.127: v1(129.78,133.42) 129.78,132.87 129.74,132.84 UV1.J16
M_MAA1_7: length 40.6
  TOP w0.127: v1(128.57,133.4) 128.57,132.85 128.65,132.77 129.47,132.77 129.66,132.57 129.66,132 129.79,131.87 130.4,131.87 130.97,131.3 130.97,131.19 131.97,130.18 132.24,130.18 132.37,130.32 132.37,130.55 132.51,130.68 133.69,130.68 133.77,130.6 133.77,130.19 133.9,130.06 134.76,130.06 135.43,129.4
  TOP w0.14: 135.43,129.4 139.59,129.4 139.8,129.18 140,129.18 140.23,129.41 140.42,129.41 140.62,129.21 140.62,129.01 140.39,128.79 140.39,128.59 140.61,128.37 140.85,128.37 141.89,129.41 142.17,129.41 142.36,129.22 142.36,129.02 141.26,127.92 141.26,127.72 141.46,127.52 141.66,127.52 143.09,128.95 143.27,128.95 144.07,128.15 144.07,127.51 v2(146.56,125.02) 147.17,124.4 v1(152.6,124.4)
  BOTTOM w0.112: UV15.K4 154.64,122.04 154.64,122.87 153.93,123.58 153.42,123.58 v1(152.6,124.4)
  BOTTOM w0.127: UV1.L15 128.14,132.28 128.56,132.7 128.56,132.94 128.57,132.95 v1(128.57,133.4)
M_MAA1_8: length 39.5
  TOP w0.127: v1(130.62,132.2) 130.62,132.05 131.26,131.4 131.89,131.4 132.38,130.9 133.79,130.9 134.27,130.42 134.88,130.42
  TOP w0.14: v1(153.74,124.4) 153.32,124.82 148.08,124.82 147.26,125.64 147.26,126.29 147.12,126.43 145.83,126.43 145.69,126.57 145.69,126.85 145.83,126.99 147.12,126.99 147.26,127.13 147.26,127.39 147.11,127.54 144.72,127.54 144.55,127.71 144.55,128.04 144.7,128.19 147.13,128.19 147.26,128.32 147.26,128.63 147.12,128.78 v2(145.87,128.78) 144.12,128.78 143.01,129.89 135.4,129.89 134.88,130.42
  BOTTOM w0.112: UV15.J5 155.11,123.04 v1(153.74,124.4)
  BOTTOM w0.127: UV1.G14 131.24,131.6 130.63,132.2 v1(130.62,132.2)
M_RASA#0: length 43.4
  TOP w0.102: 154.71,138.12 155.32,138.73 155.91,138.73 v1(156.31,138.33)
  TOP w0.127: v1(130.93,137.96) 130.93,137.6 130.64,137.31 129.9,137.31 129.63,137.04 129.63,135.65 130.21,135.08 131.66,135.08 131.75,134.99 135.55,134.99
  TOP w0.14: 154.71,138.12 154.31,137.73 154.31,137.3 154.12,137.1 153.72,137.1 153.7,137.13 145.4,137.13 145.21,136.93 v2(145.21,136.47) 145.21,134.91 145.05,134.75 144.79,134.75 144.65,134.89 144.65,136.94 144.51,137.08 144.23,137.08 144.09,136.94 144.09,134.89 143.95,134.75 143.67,134.75 143.53,134.89 143.53,136.93 143.39,137.07 143.11,137.07 142.97,136.93 142.97,134.89 142.83,134.75 140.27,134.75 140.06,134.96 135.58,134.96 135.55,134.99
  BOTTOM w0.112: v1(156.31,138.33) 156.71,137.93 UV13.G3
  BOTTOM w0.127: UV1.G22 130.98,137.96 v1(130.93,137.96)
M_RASA#1: length 43
  TOP w0.127: 135.58,133.66 134.43,133.66 133.93,134.16 132.13,134.16 131.58,133.6 v1(131.58,133.5)
  TOP w0.14: v1(157.13,121.33) 159.06,123.26 159.06,129.51 159.56,130.01 159.56,132.17 157.55,134.17 154.42,134.17 153.41,133.17 v2(148.78,133.17) 139.61,133.17 139.41,133.37 135.88,133.37 135.58,133.66
  BOTTOM w0.102: UV1.G17 131.34,133.74 v1(131.58,133.5)
  BOTTOM w0.112: v1(157.13,121.33) UV15.G3
M_WCKA0_0: length 38.6
  IN1 w0.13: v1(159.51,139.13) 159.22,139.42 159.22,140.29 158.8,140.7 144.63,140.7 144.41,140.92 144.41,142.3 144.15,142.56 143.58,142.56 143.32,142.3 143.32,140.92 143.19,140.79 142.81,140.79 142.68,140.92 142.68,142.3 142.42,142.56 141.85,142.56 141.59,142.3 141.59,140.92 141.46,140.79 140.91,140.79 140.78,140.92 140.78,142.64 140.46,142.96 v1(140.46,143.2)
  BOTTOM w0.112: 135.31,145.66 135.3,145.66 135.29,145.67 133.94,145.67 133.06,144.79 133.06,144.32 UV1.E32 ; v1(159.51,139.13) 159.11,138.73 UV13.D4
  BOTTOM w0.122: v1(140.46,143.2) 140.23,143.2 140.22,143.21 140.17,143.21 139.58,143.8 139.58,143.83 138.99,144.42 138.96,144.42 137.72,145.66 135.31,145.66
M_WCKA0_1: length 32.8
  IN1 w0.13: v1(151.51,139.13) 151.22,138.83 151.22,138.52 150.94,138.23 149.97,138.23 149.16,137.42 143.23,137.42 142.97,137.68 142.97,139.19 142.84,139.32 142.45,139.32 142.32,139.19 142.32,137.68 142.06,137.42 141.49,137.42 141.24,137.68 141.24,139.19 141.11,139.32 140.72,139.32 140.59,139.19 140.59,137.68 140.33,137.42 139.76,137.42 139.5,137.68 139.5,139.19 139.37,139.32 138.99,139.32 138.86,139.19 138.86,137.68 138.6,137.42 138.03,137.42 137.77,137.68 137.77,139.19 137.64,139.32 137.25,139.32 137.12,139.19 137.12,137.68 136.87,137.42 135.86,137.42 135.54,137.74 134.89,137.74 134.76,137.61 134.76,137.5 v1(135.04,137.21)
  BOTTOM w0.102: UV1.A21 134.56,137.04 134.77,137.13 134.81,137.11 v1(135.04,137.21)
  BOTTOM w0.112: UV13.P4 151.11,138.73 v1(151.51,139.13)
M_WCKA1_0: length 34.2
  IN1 w0.13: v1(133.37,130.28) 133.16,130.07 133.16,129.98 133.08,129.9 133.08,129.73 133.25,129.56 133.25,128.31 132.93,127.99 132.93,127.09 134.63,125.39 136.5,125.39 136.74,125.63 139.81,125.63 140.42,125.01 150.29,125.01 151.7,123.61 158.82,123.61 159.24,123.19 159.24,122.38 v1(159.51,122.11)
  BOTTOM w0.112: v1(133.37,130.28) 133.44,130.35 133.44,130.51 133.36,130.6 UV1.E13 ; v1(159.51,122.11) UV15.D4
M_WCKA1_1: length 25.4
  IN1 w0.13: v1(150.69,122.13) 151,122.43 151,122.61 149.75,123.86 138.56,123.86 138.26,124.16 138.26,124.76 v1(138.08,124.95)
  BOTTOM w0.089: 138.3,124.54 138.3,124.32 135.8,121.83 133.27,121.83 133.23,121.87 133.22,121.87
  BOTTOM w0.112: UV1.E3 132.98,123.44 132.98,123.7 132.87,123.81 132.69,123.81 132.58,123.7 132.58,123.3 132.66,123.21 132.66,122.78 132.63,122.75 132.63,122.45 132.9,122.18 132.9,121.95 132.98,121.87 133.22,121.87 ; v1(150.69,122.13) UV15.P4
  BOTTOM w0.122: v1(138.08,124.95) 138.3,124.72 138.3,124.54
M_WCKA#0_0: length 38.7
  IN1 w0.13: v1(140.05,142.79) 140.32,142.79 140.56,142.55 140.56,140.83 140.82,140.57 141.55,140.57 141.81,140.83 141.81,142.21 141.94,142.34 142.33,142.34 142.46,142.21 142.46,140.83 142.72,140.57 143.29,140.57 143.54,140.83 143.54,142.21 143.67,142.34 144.06,142.34 144.19,142.21 144.19,140.83 144.54,140.49 158.71,140.49 159,140.2 159,139.42 v1(158.7,139.13)
  BOTTOM w0.112: 135.31,145.44 135.21,145.44 135.19,145.46 134.03,145.46 133.27,144.7 133.27,144.22 133.26,144.22 133.26,143.72 UV1.E30 ; v1(158.7,139.13) 159.1,139.53 UV13.D5
  BOTTOM w0.122: v1(140.05,142.79) 140.05,142.79 140.05,143.02 v4(139.06,144) 138.67,144.4 137.62,145.44 135.31,145.44
M_WCKA#0_1: length 32.9
  IN1 w0.13: v1(134.15,137.29) 134.39,137.29 134.54,137.44 134.54,137.7 134.8,137.96 135.63,137.96 135.95,137.64 136.78,137.64 136.91,137.77 136.91,139.28 137.16,139.54 137.73,139.54 137.99,139.28 137.99,137.77 138.12,137.64 138.51,137.64 138.64,137.77 138.64,139.28 138.89,139.54 139.46,139.54 139.72,139.28 139.72,137.77 139.85,137.64 140.24,137.64 140.37,137.77 140.37,139.28 140.63,139.54 141.2,139.54 141.45,139.28 141.45,137.77 141.58,137.64 141.97,137.64 142.1,137.77 142.1,139.28 142.36,139.54 142.93,139.54 143.19,139.28 143.19,137.77 143.32,137.64 149.07,137.64 149.88,138.45 150.85,138.45 151,138.61 151,138.83 v1(150.71,139.13)
  BOTTOM w0.102: UV1.C21 133.86,137 v1(134.15,137.29)
  BOTTOM w0.112: UV13.P5 151.11,139.52 v1(150.71,139.13)
M_WCKA#1_0: length 33.9
  IN1 w0.13: v1(158.7,122.09) 159.02,122.42 159.02,123.1 158.73,123.39 151.61,123.39 150.2,124.8 140.33,124.8 139.72,125.41 136.83,125.41 136.59,125.17 134.54,125.17 132.72,127 132.72,128.08 133.03,128.4 133.03,129.47 132.86,129.64 132.86,130.06 v1(132.77,130.14)
  BOTTOM w0.102: UV1.D12 v1(132.77,130.14)
  BOTTOM w0.112: UV15.D5 v1(158.7,122.09)
M_WCKA#1_1: length 25.3
  IN1 w0.13: v1(151.49,122.13) 151.49,122.13 151.22,122.4 151.22,122.7 149.84,124.07 138.66,124.07 138.48,124.25 138.48,124.76 v1(138.66,124.95)
  BOTTOM w0.089: 138.52,124.54 138.52,124.27 135.88,121.64 133.19,121.64
  BOTTOM w0.112: v1(151.49,122.13) 151.49,122.13 UV15.P5 ; 133.19,121.64 133.19,121.63 132.88,121.63 132.66,121.85 132.66,122.08 132.42,122.32 132.42,122.84 132.45,122.87 132.45,123.13 132.14,123.44 UV1.F4
  BOTTOM w0.122: 138.52,124.54 138.52,124.81 v1(138.66,124.95)
M_WEA#0: length 42.1
  TOP w0.127: 133.74,141.96 133.74,141.25 133.94,141.04 133.94,140.9 133.41,140.37 133.21,140.37 132.71,140.87 132.02,140.87 131.43,140.28 131.43,140.06 131.57,139.93 v1(131.74,139.93)
  TOP w0.14: 133.74,141.96 133.79,142.01 133.79,143.23 133.66,143.35 132.67,143.35 132.59,143.44 132.59,143.8 132.69,143.9 134.55,143.9 134.71,143.75 134.71,143.3 134.46,143.06 134.46,142.79 134.64,142.62 135.19,142.62 135.67,143.1 137.77,143.1 137.86,143.19 138.06,143.19 138.14,143.11 138.34,143.11 138.53,143.31 138.53,143.51 138.45,143.58 138.45,143.78 138.65,143.98 138.85,143.98 139.23,143.6 139.42,143.6 139.62,143.8 139.62,144 139.24,144.38 139.24,144.57 139.5,144.82 140.47,144.82 140.61,144.69 140.61,144.55 140.75,144.41 141.03,144.41 141.17,144.55 141.17,144.69 141.31,144.82 141.75,144.82 v2(141.92,144.66) 145.58,144.66 145.87,144.95 145.87,145.8 146.05,145.98 146.38,145.98 146.52,145.84 146.52,145.56 146.66,145.42 146.92,145.42 147.06,145.56 147.06,146.21 147.2,146.35 151.92,146.35 152.19,146.08 152.69,146.08 152.95,146.35 153.37,146.35 153.54,146.19 153.54,145.82 153.43,145.7 152.95,145.7 152.82,145.56 152.82,145.23 152.93,145.12 153.73,145.12 153.89,144.96 v1(153.89,144.72)
  BOTTOM w0.102: UV1.G25 131.34,140.57 131.68,140.9 131.8,140.9 132.04,140.67 132.04,140.52 131.74,140.23 v1(131.74,139.93)
  BOTTOM w0.112: v1(153.89,144.72) 153.77,144.6 153.69,144.6 153.43,144.87 153.43,145.04 UV13.L12
M_WEA#1: length 42.5
  TOP w0.127: 136.58,124.54 135.64,125.48 135.39,125.48 135.14,125.23 134.83,125.23 134.41,125.65 134.41,125.83 134.73,126.14 134.73,126.32 134.57,126.48 134.39,126.48 134.07,126.16 133.89,126.16 132.91,127.15 132.23,127.15 132,127.38 131.5,127.38 131.08,127.8 v1(131.03,127.8)
  TOP w0.14: 136.58,124.54 136.58,124.44 139.07,121.95 144.48,121.95 144.84,121.58 145.23,121.58 147.52,119.29 150.34,119.29 150.48,119.43 150.48,119.64 150.62,119.78 150.9,119.78 151.04,119.64 151.04,119.43 151.22,119.25 151.22,118.99 151.35,118.85 151.63,118.85 151.77,118.99 151.77,119.15 151.91,119.29 152.92,119.29 154.33,120.7 154.33,121.5 156.71,123.88 156.71,124.94 156.85,125.08 157.12,125.08 157.26,125.22 157.26,125.5 157.12,125.64 156.85,125.64 156.71,125.78 156.71,127.14 156.57,127.27 154.34,127.27 v1(153.91,127.71)
  BOTTOM w0.102: v1(131.03,127.8) 130.89,127.8 130.54,128.15 UV1.H10
  BOTTOM w0.127: UV15.L12 v1(153.91,127.71)
MASK_BASE_LEDS#: length 51.8
  TOP w0.254: RE95.2 v2(48.8,96.54) 48.8,97.47 47.15,99.12 39.53,99.12 v1(39.28,99.37)
  IN1 w0.254: v1(39.28,99.37) 39.28,114.49 32.71,121.05 32.71,129.82 v1(32.42,130.11)
  BOTTOM w0.254: Q15.5 30.95,131.5 R89.2 31.07,131.33 31.91,130.49 32.04,130.49 v1(32.42,130.11)
  BOTTOM w0.406: Q15.5 Q15.2
MASK_SATA_LED#: length 85.8
  TOP w0.112: v1(52.71,78.09) 52.65,78.14 52.58,78.14 52.12,78.61 UE1.56 ; v1(27.72,130.22) v2(27.72,131.31)
  IN1 w0.119: v1(27.72,130.22) 28.62,131.11 29.24,131.11 30.78,132.65 31.15,132.65 32.68,131.11 40.14,131.11 46.63,124.63 46.63,119.17 42.07,114.61 42.07,105.85 v1(44.36,103.56)
  BOTTOM w0.112: v1(52.71,78.09) 52.76,78.14 53.1,78.14 54.17,79.21 54.17,97.69 53.44,98.42 49.5,98.42 v1(44.36,103.56) ; v1(27.72,130.22) 27.63,130.31 R26.2 RC158.1 26.3,131.83 Q3.2
MCT: length 6.9
  TOP w0.112: v2(17.08,77.47) v1(17.69,77.47)
  TOP w0.508: v1(17.69,77.47) 18,77.15 RL12.1 RL13.1
  BOTTOM w0.508: CL20.1 20.35,77.15 RL13.1 RL12.1 18,77.15 v1(17.69,77.47)
MCT0: length 9.7
  TOP w0.127: v1(17.75,76.07) v2(17.13,76.07)
  TOP w0.254: RL12.2 18.58,75.81 18.32,76.07 v1(17.75,76.07) ; TL1.3 18.02,70.59 v1(18.39,70.23)
  IN2 w0.254: v1(17.75,76.07) 17.18,75.5 17.18,71.43 v1(18.39,70.23)
MCT1: length 14
  TOP w0.127: v2(14.94,66.59) 15.13,66.78 TL1.6
  TOP w0.254: v1(18.45,67.18) 18.05,66.78 TL1.6 ; RL13.2 v1(19.85,74.93)
  IN1 w0.254: v1(18.45,67.18) 17.81,67.81 17.81,73.91 18.83,74.93 v1(19.85,74.93)
MCT2: length 10
  IN2 w0.254: v1(18.45,71.12) 17.81,71.75 17.81,75.31 18.58,76.07 v1(18.58,76.45)
  BOTTOM w0.127: v2(17.12,77.14) 17.67,76.58 18.45,76.58 v1(18.58,76.45)
  BOTTOM w0.254: v1(18.58,76.45) RL14.2 ; v1(18.45,71.12) 17.92,70.59 TL2.6
MCT3: length 17.1
  IN1 w0.254: v1(19.85,76.45) 17.31,73.91 17.31,67.62 v1(18.45,66.48)
  BOTTOM w0.127: v2(17.05,75.76) 17.64,75.18 19.27,75.18 RL15.2
  BOTTOM w0.254: TL2.3 18.15,66.78 v1(18.45,66.48) ; v1(19.85,76.45) RL15.2
ME_FWP: length 169.2
  TOP w0.102: 43.72,82.35 43.75,82.39 UE1.80
  TOP w0.112: v1(38.32,76) 38.9,76.58 40.74,76.58 41.5,77.34 41.5,78.16 43.6,80.26 43.6,82.23 43.72,82.35
  IN1 w0.119: v1(38.32,76) 31.34,76 28.48,73.15 28.48,65.46 33.5,60.45 33.5,57.53 34.39,56.64 34.39,51.65 36.13,49.91 v1(39.02,49.91)
  BOTTOM w0.112: RC50.1 110.2,62.66 107.39,62.66 107.2,62.46 105.47,62.46 105.13,62.8 102.86,62.8 99.69,59.63 99.69,58.3 100.39,57.6 100.39,49.26 97.72,46.59 97.72,45.37 97.06,44.71 97.06,43.84 95.16,41.94 94.3,41.94 92.34,39.99 90.9,39.99 88.67,37.75 88.28,37.75 88.17,37.64 v2(88.17,36.2) 88.17,33.14 89.07,32.24 89.07,30.1 90.77,28.41 90.77,27.55 90.4,27.18 69.13,27.18 63.69,32.63 59.88,32.63 58.04,34.47 58.04,35.67 57.1,36.61 55.36,36.61 54.89,37.08 47.99,37.08 46.47,38.61 45.33,38.61 38.64,45.29 38.64,48.98 38.64,48.98 38.64,49.3 38.64,49.31 38.64,49.53 v1(39.02,49.91)
MEC_XTAL1: length 2.9
  TOP w0.112: YE1.1 31.07,70.76 32.02,69.82 CE25.1 RE43.2
MEC_XTAL1_R: length 2.9
  TOP w0.112: UE1.123 34.73,71.41 34.72,71.39 v2(34.05,71.39) 33.39,70.73 RE43.1
MEC_XTAL2: length 6.3
  TOP w0.112: YE1.2 31.5,68.26 CE27.1 RE42.1 33.16,68.95 33.66,69.45 33.66,69.68 v2(34.08,70.09) 34.59,70.61 UE1.125
MEM_SMBCLK: length 17.5
  IN3 w0.089: 127.64,49.71 127.73,49.8 128.03,49.8
  IN3 w0.102: v1(128.02,50.78) 128.02,50.7 128.3,50.42 128.3,50.07 128.03,49.8
  IN3 w0.135: 127.64,49.71 127.64,49.63 127.68,49.59 127.68,49.5 127.65,49.47 127.65,48.45 128.49,47.6 128.49,46.41 127.61,45.52 127.61,44.45 127.04,43.88 127.04,42.8 128.05,41.79 128.05,40.67 127.76,40.38 127.42,40.38 127.29,40.25 127.29,39.99 v1(127.37,39.91)
  BOTTOM w0.102: UC1.CK14 128.37,50.78 v1(128.02,50.78)
  BOTTOM w0.112: QC1.6 128.46,39.78 128.69,39.56 RC198.2 128.88,39.32 127.53,39.32 127.37,39.48 v1(127.37,39.91)
MEM_SMBDATA: length 17.9
  IN3 w0.135: v1(127,51.65) 127.42,51.24 127.42,50.07 127.42,49.5 127.38,49.47 127.38,48.34 128.23,47.49 128.23,46.52 127.34,45.63 127.34,44.55 126.78,43.99 126.78,42.69 127.79,41.69 127.79,40.78 127.65,40.64 127.42,40.64 127.27,40.8 v1(127.27,41.61)
  BOTTOM w0.102: v1(127,51.65) UC1.CH15
  BOTTOM w0.112: QC1.3 127.32,41.08 127.97,41.73 RC199.2 127.62,42.1 127.29,41.76 127.29,41.61 v1(127.27,41.61)
MIC_CAP: length 2.2
  TOP w0.203: UA1.15 31.86,16.09 31.73,16.21 31.73,17.6 CA23.1
MODEL_ID: length 19.9
  TOP w0.112: RE3.2 30.96,86.32 RE4.2 CE10.1 v1(33.12,85.74) 33.32,85.94 33.32,86.85 v2(33.66,87.19) ; v1(38.18,76.57) 38.13,76.57 37.69,77.01 UE1.109
  IN1 w0.119: v1(38.18,76.57) 38.64,76.57 38.96,76.89 38.96,78.61 36.42,81.15 36.42,84.22 35.18,85.46 33.41,85.46 v1(33.12,85.74)
MSCLK: length 2.4
  TOP w0.112: RE49.2 40.98,95.21 v2(40.98,95.92) 40.98,96.16 41.25,96.43 JDEG1.6
MSDATA: length 5.3
  TOP w0.112: v2(39.18,93.02) 39.28,93.13 39.28,94.61 39.62,94.94 RE57.1 RE50.2 40.48,96.36 40.75,96.63 JDEG1.7
NB_MUTE#: length 8.3
  TOP w0.112: v1(33.69,73.17) 34.38,73.17 34.54,73.01 UE1.119 ; RE29.1 29.43,73.31 v2(29.43,74.07) 29.78,74.07 v1(30.01,73.85)
  IN3 w0.135: v1(30.01,73.85) 30.01,73.46 30.39,73.08 30.83,73.08 31.15,72.77 33.31,72.77 33.69,73.15 v1(33.69,73.17)
NCT7718_DXN: length 136.5
  IN1 w0.254: v1(182.85,59.94) 182.65,59.94 182.03,60.57 182.03,65 170.32,76.71 170.32,87.76 169.9,88.18 169.9,93.09 158.66,104.33 144.86,104.33 141.02,108.16 134.23,108.16 130.52,111.87 124.51,111.87 122.08,114.3 114.21,114.3 112.94,115.57 97.98,115.57 97.25,116.3 97.25,116.89 v1(97.21,116.93)
  BOTTOM w0.254: Q13.3 87.84,116.95 88.24,117.34 C29.2 89.12,117.66 90.8,117.66 90.83,117.7 v2(91.65,117.7) 96.94,117.7 97.21,117.43 v1(97.21,116.93) ; U3.3 181.19,60.9 C30.2 181.38,60.38 181.71,60.38 182.1,59.99 182.8,59.99 v1(182.85,59.94)
NCT7718_DXP: length 138.4
  IN1 w0.254: v1(97.8,116.93) 97.76,116.89 97.76,116.51 98.19,116.07 113.15,116.07 114.42,114.8 122.29,114.8 124.72,112.37 130.73,112.37 134.44,108.67 141.23,108.67 145.07,104.83 158.87,104.83 170.4,93.3 170.4,88.39 170.82,87.97 170.82,76.92 182.53,65.21 182.53,60.78 182.79,60.53 v1(182.85,60.53)
  BOTTOM w0.254: v1(97.8,116.93) 97.72,117.01 97.72,117.64 97.15,118.21 90.62,118.21 90.59,118.17 89.38,118.17 C29.1 88.67,118.88 Q13.2 86.22,118.88 85.25,117.91 Q13.1 ; v1(182.85,60.53) 182.83,60.5 182.32,60.5 182.03,60.8 182.03,61.03 C30.1 181.79,61.22 U3.2
NRB_BIT: length 4.7
  TOP w0.112: v1(119.16,52.52) 119.21,52.52 v2(119.7,52.03) 120.43,51.3 120.43,50.68 RC112.2
  BOTTOM w0.076: UC1.CE29 118.86,53.89 119.16,53.59 v1(119.16,52.52)
NTC_CHG: length 4.1
  TOP w0.112: v2(202.84,43.9) 202.27,44.47 PRB13.2
  TOP w0.203: v1(201.33,45.84) 201.77,45.84 202.27,45.35 PRB13.2
  BOTTOM w0.203: PUB01.13 201.94,45.72 201.87,45.8 201.37,45.8 v1(201.33,45.84)
PANEL_BKEN_EC: length 240.8
  TOP w0.112: v1(37.09,73.44) 36.72,73.81 UE1.117 ; v1(217.19,46.8) 217.23,46.76 217.23,46.26 v2(217.17,46.2) 217.13,46.16 R78.2
  IN1 w0.119: v1(37.09,73.44) 36.6,72.94 36.6,70.88 33.77,68.05 v1(33.77,67.84)
  IN2 w0.124: v1(217.19,46.8) 217.9,46.8 218.74,45.96 218.74,42.28 217.62,41.15 214.87,41.15 212.51,38.79 212.51,37.52 211.64,36.65 208.08,36.65 206.72,35.3 198.44,35.3 197.63,34.48 180.18,34.48 176.54,30.85 173.2,30.85 170.99,33.07 164.87,33.07 164.14,32.34 146.17,32.34 145.19,33.32 134.92,33.32 131.86,30.26 116.83,30.26 115.52,28.95 101.59,28.95 99.61,26.96 68.78,26.96 67.87,27.87 66.43,27.87 65.82,27.25 61.43,27.25 60.27,28.41 59.81,28.41 54.59,33.63 50.31,33.63 44.68,39.26 44.68,53.6 45.61,54.53 45.61,58.32 42.38,61.54 41.5,61.54 39.86,63.18 39.17,63.18 38.56,63.79 37.04,63.79 34.2,66.63 34.2,67.42 v1(33.77,67.84)
PBAT_CHG_SMBCLK: length 258.6
  TOP w0.112: UE1.9 40.55,66.86 40.74,66.67 40.74,65.95 40.22,65.44 40.22,65.4 v1(40.41,65.21) 40.37,65.16 40.37,64.83 RE9.1 ; v1(162.01,27.24) 162.18,27.41 162.18,33.54 161.09,34.63 161.09,37.5 161.54,37.95 161.85,37.95 161.97,38.07 161.97,38.22 PD5.3 161.96,38.98 161.96,39.43 161.78,39.61 PR42.2
  IN1 w0.119: v1(206.34,51.12) 206.33,51.12 206.17,51.29 206.16,52.2 206.28,52.32 208.25,52.32 208.76,51.81 208.76,50.03 209.9,48.89 209.9,47.74 212.63,45.01 212.63,35.09 210.91,33.37 209.3,33.37 207.77,31.84 181.34,31.84 176.29,26.78 173.16,26.78 172.07,27.87 167.71,27.87 167.55,27.71 166.02,27.71 165.92,27.82 162.62,27.82 162.46,27.65 162.42,27.65 162.18,27.41 162.18,27.41 v1(162.01,27.24)
  IN3 w0.135: v1(162.01,27.24) 162.17,27.07 162.17,26.47 162.04,26.34 148.01,26.34 143.22,31.13 139.88,31.13 134.48,25.72 110.91,25.72 107.49,29.14 98.97,29.14 98.45,29.66 96.82,29.66 94.01,26.86 68.68,26.86 67.98,27.55 61.61,27.55 58.3,30.86 57.61,30.86 55.94,32.53 54.62,32.53 53.93,33.22 49.5,33.22 42.46,40.26 42.46,46.08 41.51,47.03 41.51,53.15 44.56,56.2 44.56,60.95 42.96,62.54 42.96,63.43 42.5,63.89 41.09,63.89 40.29,64.69 40.3,64.89 40.3,65.1 v1(40.41,65.21)
  BOTTOM w0.112: v1(206.34,51.12) 206.34,50.5 PRB20.1
PBAT_CHG_SMBDAT: length 260.2
  TOP w0.112: PR37.2 162.31,39.61 162.2,39.49 162.2,38.99 PD5.2 162.21,38.22 162.21,37.97 161.95,37.72 161.64,37.72 161.32,37.4 161.32,34.73 162.42,33.64 v4(162.42,32.06) 162.42,27.41 v1(162.59,27.24) ; RE8.1 40.05,64.66 40.05,65 v1(39.83,65.22) 39.98,65.37 39.98,65.54 40.5,66.05 40.5,66.53 40.15,66.87 UE1.8
  IN1 w0.119: v1(205.75,51.12) 205.92,51.29 205.91,52.3 206.18,52.57 208.35,52.57 209,51.91 209,50.14 210.15,48.99 210.15,47.84 212.88,45.11 212.88,34.99 211.01,33.12 209.4,33.12 207.87,31.59 181.44,31.59 176.39,26.54 173.06,26.54 171.97,27.63 167.81,27.63 167.65,27.46 165.92,27.46 165.81,27.57 162.73,27.57 162.55,27.4 162.55,27.27 v1(162.59,27.24)
  IN3 w0.135: v1(162.59,27.24) 162.43,27.08 162.43,26.37 162.15,26.08 147.9,26.08 143.11,30.87 139.99,30.87 134.59,25.46 110.8,25.46 107.38,28.88 98.86,28.88 98.34,29.4 96.92,29.4 94.12,26.59 68.57,26.59 67.87,27.29 61.5,27.29 58.19,30.6 57.5,30.6 55.84,32.27 54.51,32.27 53.83,32.96 49.39,32.96 42.2,40.15 42.2,45.97 41.25,46.92 41.25,53.26 44.29,56.31 44.29,60.84 42.7,62.43 42.7,63.32 42.39,63.63 40.98,63.63 40.03,64.58 40.04,64.89 40.04,65.01 v1(39.83,65.22)
  BOTTOM w0.112: PRB19.1 205.75,50.53 v1(205.75,51.12)
PBAT_PRES#: length 243.8
  TOP w0.112: CE18.1 49.58,65.91 48.99,65.91 48.55,66.35 UE1.29 48.55,68.83 48.29,69.08 48.08,69.08 45.85,71.32 44.14,71.32 43.47,72 v1(42.15,72)
  TOP w0.254: PD6.2 166.91,39.61 PR41.1 PR39.2 PC14.1 165.76,38.68 v2(166.33,38.11) 166.33,37.43 165.86,36.96 v1(165.86,36.76)
  IN2 w0.124: v1(42.15,72) 42.07,72 41.21,71.13 41.21,67.33 41.03,67.15 41.03,65.63 42.78,63.88 42.78,63.07 46.96,58.88 46.96,55.88 48.42,54.42 48.42,49.03 46.63,47.23 46.63,39.55 50.96,35.21 55.25,35.21 60.39,30.07 60.85,30.07 61.46,29.46 65.26,29.46 65.87,30.07 69.93,30.07 70.1,30.24 92.51,30.24 95.87,33.6 118.04,33.6 119.33,34.89 121.54,34.89 122.84,33.59 123.95,33.59 125.41,35.05 128.11,35.05 129.45,33.71 132.11,33.71 134.14,35.75 138.71,35.75 142.17,39.2 142.8,39.2 144.17,37.83 146.56,37.83 147.45,36.94 151.49,36.94 152.88,35.56 164.31,35.56 165.51,36.76 v1(165.86,36.76) 167.06,35.56 171.47,35.56 173.14,37.23 180.01,37.23 180.39,37.6 189.83,37.6 190.34,37.1 195.69,37.1 197.07,38.48 204.74,38.48 205.9,39.64 205.9,40.63 206.54,41.26 207.12,41.26 209.92,44.06 210.55,44.06 210.67,44.19 210.67,48.05 v1(210.66,48.06)
  BOTTOM w0.203: PRB24.2 210.21,50.43 210.96,49.68 210.96,48.36 v1(210.66,48.06)
PBAT_PRES#_R: length 4.4
  TOP w0.254: v1(163.61,41.33) 163.61,40.95 v2(164.04,40.52) PR39.1
  BOTTOM w0.254: PBATT1.5 165.01,40.44 164.75,40.7 163.86,40.7 163.61,40.95 v1(163.61,41.33)
PCH_3.3V_TS_EN: length 124.8
  TOP w0.112: v1(126.79,39.87) 126.79,39.86 127.31,39.34 128.8,39.34 129.48,38.66 129.48,37.41 131.44,35.45 133.03,35.45 134.44,34.05 144.4,34.05 146.49,31.96 v2(154.87,31.96) 156.06,31.96 160.11,27.9 v1(160.11,27.25) ; v1(212.11,31.69) 211.46,32.34 211.46,33.47 R72.1 212.09,34.09 212.09,35.04 U2.4
  IN1 w0.119: v1(160.11,27.25) 160.11,27.05 160.7,26.46 169.14,26.46 170.44,25.16 176.78,25.16 181.79,30.18 210.6,30.18 v1(212.11,31.69)
  IN3 w0.089: 126.52,52.69 126.52,52.8 126.13,53.18 125.57,53.18 124.93,53.83 123.73,53.83 123.59,53.97 123.59,55.28 123.45,55.42 123.01,55.42 121.42,53.83 119.52,53.83
  IN3 w0.135: 119.52,53.83 118.96,53.83 118.47,54.31 v1(118.47,54.35) ; 126.52,52.69 126.52,49.88 126.35,49.71 126.35,48.71 127.27,47.79 127.27,46.87 126.13,45.73 126.13,40.54 v1(126.79,39.87)
  BOTTOM w0.076: UC1.CC30 118.21,54.61 v1(118.47,54.35)
PCH_BATLOW#: length 2.8
  BOTTOM w0.102: UC1.BV36 114.11,57.59 113.73,57.59 113.22,57.08 RC96.2
PCH_DPWROK: length 13.6
  TOP w0.112: v1(117.95,59.85) 117.47,60.32 111.47,60.32 110.96,60.84 107.04,60.84 v2(106.42,61.46) 105.57,61.46
  BOTTOM w0.102: UC1.BP30 v1(117.95,59.85)
PCH_JTAG_TCK1: length 12.6
  TOP w0.112: v1(133.49,82.76) 133.89,82.36 134.55,82.36 TPC3.1 134.74,82.52 136.1,83.88 137.57,83.88 138.5,82.94 143.43,82.94 143.7,82.67 RC157.1
  BOTTOM w0.102: UC1.W6 v1(133.49,82.76)
PCH_PCIE_WAKE#: length 15
  TOP w0.112: v1(117.97,58) 117.77,57.8 116.16,57.8 115.97,57.99 114.47,57.99 113.72,57.23 110.78,57.23 110.14,56.6 108.36,56.6 v2(107.21,55.45) 106.49,54.73 RC92.2 105.9,54.3 105.57,53.97
  BOTTOM w0.089: v1(117.97,58) UC1.BU30
PCH_PLTRST#: length 29.8
  TOP w0.112: UC4.1 98.25,53.64 98.59,53.97 ; 98.59,53.97 98.76,53.79 v2(99.08,53.79) 99.22,53.65 99.22,53.4 v1(98.97,53.14) ; 98.59,53.97 98.27,54.29 UC4.2
  BOTTOM w0.102: 104.95,63.53 105.63,62.85 107.03,62.85 107.23,63.05 110.08,63.05 110.43,63.41 112.94,63.41 113.21,63.13 114.94,63.13 UC1.BJ35
  BOTTOM w0.112: 104.95,63.53 102.49,63.53 98.71,59.75 98.71,58.25 99.66,57.29 99.66,53.84 v1(98.97,53.14)
PCH_POPIRCOMP: length 3
  TOP w0.112: RC16.1 120.54,56.34 120.24,56.64 119.75,56.64 119.51,56.88 v2(119.03,56.88)
  TOP w0.254: v1(120.63,56.96) 120.55,56.88 RC16.1
  BOTTOM w0.254: UC1.BW25 120.94,57.27 v1(120.63,56.96)
PCH_PRIM_EN: length 196
  TOP w0.112: v3(71.95,27.73) v1(71.95,28.33) RZ8.2 71.99,29.56 RZ4.1
  IN2 w0.124: v1(71.95,28.33) 72.87,27.42 90.89,27.42 92.07,28.6 92.71,28.6 93.9,27.42 95.54,27.42 96.1,27.98 96.1,29.32 97.62,30.84 115.62,30.84 116.01,31.23 117.44,31.23 117.97,30.71 131.67,30.71 134.73,33.77 145.38,33.77 146.36,32.79 163.95,32.79 164.68,33.52 172.44,33.52 173.86,34.94 196.41,34.94 197.9,36.43 206.96,36.43 207.64,37.11 211.39,37.11 212.01,37.73 212.01,38.94 214.68,41.61 216.82,41.61 217.73,42.51 217.73,45.52 216.43,46.83 216.43,48.33 217.34,49.25 217.34,50.89 217.11,51.12 216.45,51.12 216.33,51 215.55,51 215.43,51.12 215.43,55.44 214.8,56.07 212.82,56.07 212.19,56.7 202.7,56.7 v1(199.84,59.56)
  BOTTOM w0.112: PR1801.1 202.87,59.61 202.42,60.05 200.34,60.05 v1(199.84,59.56)
PCH_RSMRST#: length 138.1
  TOP w0.112: RE26.1 48.37,66.23 48.36,66.23 47.75,66.83 UE1.27 47.75,68.52 45.59,70.69 42.17,70.69 v1(42.15,70.67) ; UC5.1 95.21,58.49 94.05,57.34 91.97,57.34 91.35,56.71 v2(91.35,54.86) 91.35,46.48 91.66,46.16 91.66,46.04 v1(91.67,46.04)
  IN2 w0.124: v1(78.65,31.05) 78.07,30.47 70,30.47 69.83,30.3 65.77,30.3 65.16,29.69 61.55,29.69 60.95,30.3 60.48,30.3 55.34,35.44 51.06,35.44 46.85,39.64 46.85,47.14 48.65,48.93 48.65,54.52 47.19,55.98 47.19,58.97 43,63.16 43,65.29 42.81,65.48 42.81,66.53 42.15,67.19 v1(42.15,70.67)
  BOTTOM w0.112: v1(78.65,31.05) 81.19,28.5 88.37,28.5 88.71,28.84 88.71,29.37 87.69,30.39 87.69,32.13 86.64,33.17 86.64,37.77 87.45,38.58 88.48,38.58 92.24,42.34 92.5,42.34 93.03,42.87 94.78,42.87 96.13,44.22 96.13,46.81 95.67,47.26 94.22,47.26 93.89,46.93 93.07,46.93 92.79,46.64 92.27,46.64 v1(91.67,46.04)
PCH_RSMRST#_Q: length 25.4
  TOP w0.112: RC101.1 104.63,61.46 v1(104.44,61.65) 104.25,61.46 103.86,61.46 103.8,61.53 RC155.1 103.36,61.22 103.15,61.01 101.25,61.01 100.65,60.42 100.65,59.17 101.13,58.69 101.13,57.81 99.74,56.43 v2(99.23,56.43) 98.66,56.43 97.9,57.19 UC5.4 97.05,57.19 96.81,56.95 96.81,56.7 97.01,56.5 RC75.2
  BOTTOM w0.076: 104.51,61.58 105.79,60.31 106.74,60.31 107.51,59.54 112.21,59.54 112.52,59.85 114.03,59.85 114.52,59.59 UC1.BR36
  BOTTOM w0.112: 104.51,61.58 v1(104.44,61.65)
PCH_RTCRST#: length 17.7
  TOP w0.112: v3(107.21,57.7) 106.91,57.4 RC82.2 CC8.1 105.93,58.31 CLRP2.1 v1(106.71,59.43)
  BOTTOM w0.076: UC1.BR34 115.24,59.28 113.57,59.28 113.5,59.35 113.18,59.35 113.04,59.22 107.98,59.22 107.42,58.65 105.09,58.65 105.01,58.73 105.01,59.04 105.09,59.11 106.4,59.11 v1(106.71,59.43)
PCH_RTCX1: length 25.1
  TOP w0.112: v1(105.08,48.57) 105.46,48.19 v2(105.46,48.14) 105.46,47.49 RC95.2 105.08,46.27 CC11.1 105.14,44.75 105.33,44.56 YC2.1
  IN3 w0.135: v1(117.33,60.74) 117.26,60.74 116.68,60.16 116.22,60.16 114.97,58.9 114.97,57.46 113.95,56.45 112.94,56.45 108.95,52.46 106.38,52.46 105.75,51.82 105.75,49.25 v1(105.08,48.57)
  BOTTOM w0.076: UC1.BN31 v1(117.33,60.74)
PCH_RTCX2: length 25.2
  TOP w0.112: YC2.2 103.94,44.56 104.28,44.89 CC12.1 104.16,46.32 RC95.1 v2(104.16,48.09) v1(104.16,48.6)
  IN3 w0.135: v1(104.16,48.6) 104.16,48.94 104.87,49.65 104.87,52.14 106,53.27 108.55,53.27 112.63,57.34 113.49,57.34 114.18,58.03 114.18,59.16 115.75,60.73 v1(116.69,60.73)
  BOTTOM w0.076: UC1.BN32 v1(116.69,60.73)
PCH_SMBCLK: length 228.2
  TOP w0.112: US2.1 170.23,28.84 169.96,28.57 169.96,27.41 v1(169.68,27.14) ; v1(77.65,39.8) 77.65,39.95 77.76,40.06 78.13,40.06 78.71,39.48 78.71,33.84 80.72,31.84 81.99,31.84 86.89,26.94 87.18,26.94 98.45,26.94 99.48,27.97 99.48,28.92 100.04,29.48 100.04,32.8 101.99,34.75 107.5,34.75 108.35,33.9 115.2,33.9 117.45,31.65 120.02,31.65 120.56,32.19 124.1,32.19 127.01,35.1 127.01,37.34 126.65,37.7 126.65,38.73 125.99,39.39 125.99,40.2 126.37,40.58 129.19,40.58 130.79,38.98 v1(130.79,38.65) 130.97,38.65 133.15,36.48 133.15,36.04 134.64,34.54 144.62,34.54 146.71,32.45 153.29,32.45 155.69,34.86 159.34,34.86 160.87,33.32 160.87,27.41 v1(160.7,27.24) ; v1(218.7,33.1) 218.63,33.1 218.48,33.25 JVGA1.12
  IN1 w0.119: v1(218.7,33.1) 218.53,33.27 217.83,33.27 215.96,31.41 215.16,31.41 213.74,32.83 212.54,32.83 210.56,30.85 181.75,30.85 176.7,25.79 170.52,25.79 169.86,26.44 169.86,26.95 v1(169.68,27.14)
  IN3 w0.135: v1(169.68,27.14) 169.73,27.14 169.87,27 169.87,26.48 169.73,26.35 164.45,26.35 162.73,28.07 161.11,28.07 160.82,27.78 160.82,27.36 v1(160.7,27.24) ; v1(77.65,39.8) 77.49,39.96 77.49,39.97 77.43,40.02 77.43,40.77 77.03,41.18 69.41,41.18 68.98,41.6 65.2,41.6 65.07,41.47 64.7,41.47 64.56,41.6 64.56,41.83 v1(64.66,41.93)
  BOTTOM w0.112: QC1.1 125.73,39.78 125.43,39.48 RC29.2 125.13,39.08 125.38,38.82 129.29,38.82 129.45,38.99 130.65,38.99 130.79,38.84 v1(130.79,38.65) ; v1(64.66,41.93) 64.51,42.07 64.51,42.51 64.06,42.97 63.58,42.97 62.3,44.26 62.3,44.49 62.93,45.13 65.01,45.13 65.15,44.99 JDIMM2.253 ; v1(77.65,39.8) 77.64,39.8 77.64,39.8 77.5,39.94 77.5,40.71 77.13,41.08 77.11,41.08 76.14,42.04 76.14,42.82 75.17,43.79 75.17,44.67 75.58,45.08 77.95,45.08 78.04,44.99 JDIMM1.253
PCH_SMBDATA: length 224.6
  TOP w0.112: JVGA1.11 218.35,33.75 218.41,33.68 v1(218.68,33.68) ; v1(161.28,27.24) 161.11,27.41 161.11,33.42 159.44,35.09 155.59,35.09 153.19,32.69 146.81,32.69 144.72,34.78 134.74,34.78 133.38,36.14 133.38,36.58 131.23,38.73 131.23,39.68 130.27,40.63 130.27,41.21 129.64,41.84 v1(129.5,41.84) 129.46,41.84 128.44,40.82 126.27,40.82 125.75,40.3 125.75,39.29 126.41,38.63 126.41,37.6 126.77,37.24 126.77,35.2 124,32.43 120.46,32.43 119.92,31.89 117.55,31.89 115.3,34.14 108.45,34.14 107.6,34.98 101.89,34.98 99.8,32.9 99.8,29.58 99.24,29.02 99.24,28.07 98.35,27.18 87.09,27.18 86.99,27.18 82.09,32.08 80.82,32.08 78.95,33.94 78.95,39.58 78.23,40.3 77.57,40.3 77.24,39.97 77.24,39.96 v1(77.06,39.79) ; v1(170.33,27.11) 170.81,27.11 171.73,28.02 US2.4
  IN1 w0.119: v1(218.68,33.68) 218.51,33.52 217.72,33.52 215.86,31.65 215.26,31.65 213.84,33.08 212.44,33.08 210.45,31.09 181.65,31.09 176.6,26.04 170.62,26.04 170.11,26.55 170.11,26.89 v1(170.33,27.11)
  IN3 w0.135: v1(161.28,27.24) 161.26,27.24 161.08,27.41 161.08,27.67 161.22,27.81 162.62,27.81 164.34,26.09 169.84,26.09 170.13,26.37 170.13,26.91 v1(170.33,27.11) ; v1(64.08,41.93) 64.3,41.7 64.3,41.49 64.59,41.21 65.17,41.21 65.31,41.34 68.87,41.34 69.3,40.92 76.92,40.92 77.17,40.66 77.17,39.9 v1(77.06,39.79)
  BOTTOM w0.112: QC1.4 129.04,41.08 RC28.2 129.19,41.57 129.46,41.84 v1(129.5,41.84) ; v1(64.08,41.93) 64.28,42.13 64.28,42.41 63.96,42.73 63.48,42.73 62.06,44.16 62.06,44.63 61.94,44.74 JDIMM2.254 ; JDIMM1.254 74.68,44.74 74.93,44.49 74.93,43.7 75.91,42.72 75.91,41.94 77.01,40.84 77.03,40.84 77.27,40.61 77.27,40 77.06,39.79 77.06,39.79 v1(77.06,39.79)
PCH_SRTCRST#: length 16.8
  TOP w0.112: v1(101.73,59.69) 101.98,59.43 CLRP1.1 102.45,59.41 CC7.1 RC77.2 101.71,57.4 v2(101.44,57.13)
  BOTTOM w0.076: 104.51,60.15 106.67,60.15 107.44,59.38 112.73,59.38 113.04,59.68 113.82,59.68 UC1.BR37
  BOTTOM w0.112: v1(101.73,59.69) 102.08,59.69 102.54,60.15 104.51,60.15
PCIE_CRX_C_DTX_N9: length 2.2
  TOP w0.112: CL9.2 26.07,85.43 26.07,85.3 25.96,85.19 25.52,85.19 25.27,84.94 25.27,84.72 25.2,84.64 UL1.18
PCIE_CRX_C_DTX_P9: length 2.2
  TOP w0.112: UL1.17 25.6,84.61 25.5,84.71 25.5,84.85 25.62,84.97 26.05,84.97 26.29,85.21 26.29,85.43 CL8.2
PCIE_CRX_DTX_N9: length 189.7
  TOP w0.112: CL9.1 26.07,87.07 26.07,87.27 v1(25.9,87.44)
  IN1 w0.089: 134.93,59.64 134.93,59.65 134.93,59.67 134.54,60.05 133.9,60.05 133.81,59.96 133.81,59.85 133.82,59.83 133.82,59.69 133.94,59.57 134.07,59.57 v1(134.17,59.67)
  IN1 w0.119: v1(25.9,87.44) 25.91,87.44 26.32,87.84 26.45,87.84 26.62,88.02 26.99,88.02 27.24,87.77 27.24,87.1 26.97,86.83 26.97,83.41 27.66,82.73 29.18,82.73 29.37,82.91 30.75,82.91 31.17,82.5 31.17,80.82 29.51,79.16 29.51,76.98 26.14,73.61 26.14,57.16 36.02,47.28 40.78,47.28 44.64,43.42 48.27,43.42 49.71,41.99 60.45,41.99 62.42,40.02 63.44,40.02 65.9,37.55 67.75,37.55 68.98,36.32 70.57,36.32 72.11,34.78 75.71,34.78 77.43,33.06 80.36,33.06 80.81,32.61 83.08,32.61 83.76,33.3 94.49,33.3 95.49,34.3 110.24,34.3 110.66,33.88 115.72,33.88 116.1,34.26 116.64,34.26 117.56,35.18 120.07,35.18 121.05,36.17 126.44,36.17 127.76,37.5 130.38,37.5 131.41,38.52 131.41,44.24 132.15,44.98 132.15,45.71 133.67,47.24 133.67,47.85 134,48.18 134.95,48.18 136.26,49.48 136.26,51.48 137.06,52.28 137.06,53.06 137.74,53.74 137.98,53.74 138.72,54.49 139.13,54.49 139.9,55.26 140.3,55.26 140.55,55.5 140.55,56.09 140.28,56.36 138.22,56.36 134.93,59.64
  BOTTOM w0.076: UC1.BP5 133.85,59.99 v1(134.17,59.67)
PCIE_CRX_DTX_N10: length 147.8
  IN3 w0.089: v1(133.42,60.61) 133.42,60.62 133.63,60.83 133.63,61.03 133.93,61.34 134.32,61.34 135.1,62.11 135.1,62.24 135.45,62.6 135.45,65.9 135.48,65.92 135.48,66.31 135.48,66.31 135.48,66.36 135.46,66.39 135.46,66.4
  IN3 w0.135: 135.46,66.4 135.46,77.52 136.15,78.21 136.15,85.69 135.49,86.35 135.49,91.23 134.34,92.39 134.34,93.05 129.22,98.17 129.22,105.62 128.57,106.27 128.57,107.32 126.72,109.17 126.72,109.98 121.79,114.91 108.22,114.91 107.41,115.72 105.22,115.72 104.97,115.47 88.22,115.47 86.17,117.51 71.86,117.51 71.4,117.05 68.37,117.05 67.79,117.64 65.55,117.64 65.2,117.99 65.2,118.63 v1(65.05,118.77)
  BOTTOM w0.102: v1(133.42,60.61) 133.2,60.83 UC1.BN6
  BOTTOM w0.112: v1(65.05,118.77) 65.05,121.61 64.11,122.55 64.11,126.31 64.48,126.68 67.66,126.68 68.04,127.05 73.95,127.05 74.84,127.94 74.84,130.23 75.2,130.6 76.51,130.6 77.16,131.25 78.14,131.25 78.24,131.15 JWLAN1.43
PCIE_CRX_DTX_N13: length 164.1
  IN1 w0.089: v1(133.51,62.55) 133.63,62.55 133.95,62.86 134.25,62.86 134.52,62.59 134.73,62.59 134.88,62.44 135.7,62.44 136.19,62.94 137.26,62.94 137.28,62.95 137.37,62.95
  IN1 w0.119: 137.37,62.95 138.71,62.95 139.52,63.76 141.53,63.76 142.07,64.3 144.18,64.3 148.05,60.43 148.05,56.65 145.23,53.82 145.23,52.53 142.54,49.84 142.54,44.22 144.69,42.07 144.69,35 143.5,33.82 136.19,33.82 134.65,32.28 133.78,32.28 132.52,31.02 131.19,31.02 127.5,27.32 100.2,27.32 99.25,26.37 70.48,26.37 67.86,29 66.11,29 62.96,32.15 61.65,32.15 60.24,33.56 58.82,33.56 56.21,36.16 55.72,36.16 55.21,35.65 47.54,35.65 45.7,37.49 40.82,37.49 39.91,36.57 39.91,36.57 39.83,36.49 38.63,36.49 38.52,36.37 v1(38.52,35.87)
  BOTTOM w0.102: v1(133.51,62.55) 133.42,62.64 133.42,62.7 UC1.BK6
  BOTTOM w0.112: v1(38.52,35.87) 38.25,35.61 38.25,35.07 38.38,34.95 JSSD1.5
PCIE_CRX_DTX_N14: length 169.8
  IN1 w0.089: 137.37,63.6 137.34,63.6 137.33,63.58 134.76,63.58 134.41,63.93 133.74,63.93 133.54,63.73 133.54,63.5 v1(133.42,63.38)
  IN1 w0.119: 137.37,63.6 138.44,63.6 139.25,64.4 140.83,64.4 141.85,65.43 143.96,65.43 148.69,60.7 148.69,56.38 147.48,55.17 147.48,54.11 146.02,52.65 146.02,52.41 143.18,49.57 143.18,44.48 145.33,42.33 145.33,34.74 143.77,33.18 136.46,33.18 134.92,31.64 134.05,31.64 132.73,30.32 131.41,30.32 127.77,26.68 100.53,26.68 99.58,25.73 70.22,25.73 67.6,28.35 65.34,28.35 64.17,29.52 61.94,29.52 56.96,34.51 55.76,34.51 55.29,34.98 47.3,34.98 45.48,36.8 41.05,36.8 39.32,35.07 36.46,35.07 36.14,35.39 36.14,35.4 35.58,35.96 35.21,35.96 35.09,35.84 v1(35.09,35.24)
  BOTTOM w0.102: v1(133.42,63.38) 133.2,63.6 UC1.BJ6
  BOTTOM w0.112: JSSD1.17 35.38,34.69 35.09,34.98 v1(35.09,35.24)
PCIE_CRX_DTX_N15: length 173.3
  IN1 w0.089: 136.91,64.12 136.89,64.12 136.86,64.14 136.1,64.14 135.56,64.69 133.81,64.69 133.73,64.61 133.73,64.5 133.78,64.45 133.78,64.38 133.86,64.3 v1(134.05,64.3)
  IN1 w0.119: 136.91,64.12 138.36,64.12 139.07,64.83 140.62,64.83 141.65,65.86 144.14,65.86 149.12,60.88 149.12,56.2 147.91,54.99 147.91,53.93 146.49,52.52 146.49,43.8 145.75,43.06 145.75,33.69 144.69,32.63 139.52,32.63 139.03,32.63 136.51,32.63 133.66,29.78 131.46,29.78 127.95,26.26 100.71,26.26 99.76,25.31 70.04,25.31 67.42,27.93 62.94,27.93 56.78,34.08 55.54,34.08 55.07,34.55 47.12,34.55 46.47,35.2 40.05,35.2 39.5,34.65 32.16,34.65 32.04,34.77 32.04,35.02 32.16,35.14 32.76,35.14 32.9,35.28 32.9,35.45 32.76,35.59 v1(32.41,35.59)
  BOTTOM w0.102: UC1.BG5 133.85,64.5 v1(134.05,64.3)
  BOTTOM w0.112: v1(32.41,35.59) 32.23,35.41 32.23,34.73 32.38,34.58 JSSD1.29
PCIE_CRX_DTX_N16: length 183.5
  IN1 w0.089: v1(134.05,65.23) 133.85,65.23 133.78,65.3 133.78,65.38 133.69,65.47 133.69,65.53 133.78,65.63 134.74,65.63 134.75,65.64 134.77,65.64 134.85,65.72 135.48,65.72 136.24,64.96 136.88,64.96 136.89,64.94 136.91,64.94
  IN1 w0.119: v1(28.84,35.97) 29.05,35.97 29.18,35.85 29.18,35.64 29.06,35.52 28.64,35.52 28.42,35.74 28.42,36.22 28.3,36.34 27.95,36.34 27.81,36.2 27.81,35.17 28.78,34.2 29.77,34.2 29.97,34.01 40.21,34.01 40.67,34.48 46.26,34.48 46.83,33.91 54.76,33.91 55.24,33.44 56.52,33.44 65.29,24.67 100.02,24.67 100.97,25.62 128.21,25.62 131.26,28.66 133.45,28.66 136.78,31.98 140.18,31.98 140.41,31.98 140.63,31.98 144.99,31.98 147.13,34.13 147.13,50.57 149.1,52.54 149.1,55.28 149.76,55.94 149.76,61.14 144.4,66.5 139.82,66.5 138.26,64.94 136.91,64.94
  BOTTOM w0.102: UC1.BE5 133.85,65.43 v1(134.05,65.23)
  BOTTOM w0.112: JSSD1.43 28.87,34.87 29.11,35.1 29.22,35.1 29.43,35.31 29.43,36.18 29.32,36.29 29.15,36.29 v1(28.84,35.97)
PCIE_CRX_DTX_P9: length 189.7
  TOP w0.112: v1(26.49,87.43) 26.3,87.23 26.3,87.07 CL8.1
  IN1 w0.089: 135.09,59.79 135.09,59.79 135.09,59.79 ; 135.09,59.79 135.04,59.84 135.02,59.84 134.63,60.23 133.83,60.23 133.63,60.03 133.63,59.85 v1(133.46,59.68)
  IN1 w0.119: 135.09,59.79 138.31,56.57 140.37,56.57 140.77,56.18 140.77,55.41 140.39,55.04 139.99,55.04 139.23,54.27 138.82,54.27 138.07,53.53 137.83,53.53 137.28,52.97 137.28,52.19 136.48,51.39 136.48,49.39 135.04,47.96 134.09,47.96 133.89,47.76 133.89,47.15 132.37,45.62 132.37,44.89 131.63,44.15 131.63,38.43 130.47,37.28 127.85,37.28 126.53,35.95 121.14,35.95 120.16,34.97 117.65,34.97 116.73,34.04 116.19,34.04 115.81,33.66 110.57,33.66 110.15,34.08 95.58,34.08 94.58,33.08 83.85,33.08 83.17,32.39 80.72,32.39 80.27,32.84 77.34,32.84 75.62,34.56 72.02,34.56 70.48,36.11 68.89,36.11 67.66,37.33 65.81,37.33 63.35,39.8 62.33,39.8 60.36,41.77 49.62,41.77 48.18,43.2 44.55,43.2 40.69,47.06 35.93,47.06 25.92,57.07 25.92,73.71 29.29,77.07 29.29,79.25 30.95,80.91 30.95,82.41 30.66,82.7 29.46,82.7 29.27,82.51 27.57,82.51 26.76,83.32 26.76,86.92 27.02,87.19 27.02,87.68 26.9,87.8 26.71,87.8 26.49,87.58 v1(26.49,87.43)
  BOTTOM w0.102: UC1.BP6 133.46,59.88 v1(133.46,59.68)
PCIE_CRX_DTX_P10: length 147.8
  IN3 w0.089: 135.69,66.4 135.69,66.39 135.67,66.37 135.67,65.85 135.64,65.82 135.64,62.52 135.29,62.16 135.29,62.03 134.4,61.15 134.01,61.15 133.82,60.95 133.82,60.83 v1(134.03,60.62)
  IN3 w0.135: v1(65.64,118.77) 65.44,118.58 65.44,118.09 65.65,117.88 67.89,117.88 68.47,117.29 71.3,117.29 71.76,117.75 86.27,117.75 88.32,115.71 104.87,115.71 105.12,115.96 107.51,115.96 108.32,115.15 121.89,115.15 126.96,110.08 126.96,109.27 128.81,107.42 128.81,106.37 129.46,105.72 129.46,98.27 134.58,93.15 134.58,92.49 135.73,91.33 135.73,86.45 136.39,85.79 136.39,78.59 136.38,78.58 136.38,78.12 135.69,77.42 135.69,66.4
  BOTTOM w0.102: v1(134.03,60.62) 134.02,60.62 134.02,60.9 UC1.BN5
  BOTTOM w0.112: JWLAN1.41 78.43,130.65 78.05,131.03 77.25,131.03 76.6,130.38 75.29,130.38 75.06,130.14 75.06,127.85 74.04,126.83 68.13,126.83 67.76,126.45 64.57,126.45 64.33,126.21 64.33,122.64 65.27,121.7 65.27,119.37 65.38,119.26 65.56,119.26 65.67,119.15 65.67,118.81 v1(65.64,118.77)
PCIE_CRX_DTX_P13: length 164.1
  IN1 w0.089: 137.37,62.74 137.34,62.74 137.33,62.75 136.26,62.75 135.77,62.26 134.81,62.26 134.66,62.42 134.52,62.42 134.48,62.37 134.48,62.16 134.36,62.05 134.03,62.05 133.97,62.11 133.97,62.37 v1(134.1,62.5)
  IN1 w0.119: v1(37.93,35.87) 37.85,35.95 37.85,36.13 37.97,36.25 38.18,36.25 38.3,36.37 38.3,36.46 38.54,36.71 39.74,36.71 39.82,36.79 40.73,37.7 45.79,37.7 47.63,35.86 55.11,35.86 55.63,36.38 56.3,36.38 58.91,33.78 60.33,33.78 61.74,32.37 63.05,32.37 66.2,29.22 67.95,29.22 70.58,26.59 99.16,26.59 100.11,27.54 127.41,27.54 131.1,31.23 132.43,31.23 133.69,32.5 134.56,32.5 136.1,34.04 143.41,34.04 144.47,35.09 144.47,41.98 142.32,44.13 142.32,49.93 145.01,52.62 145.01,53.91 147.83,56.74 147.83,60.34 144.09,64.08 142.16,64.08 141.62,63.54 139.61,63.54 138.8,62.74 137.37,62.74
  BOTTOM w0.102: v1(134.1,62.5) 134.09,62.51 134.09,62.6 133.85,62.84 UC1.BK5
  BOTTOM w0.112: JSSD1.7 37.87,34.95 38.03,35.11 38.03,35.77 v1(37.93,35.87)
PCIE_CRX_DTX_P14: length 169.8
  IN1 w0.089: 137.37,63.38 137.34,63.38 137.33,63.39 134.68,63.39 134.31,63.76 133.81,63.76 133.71,63.66 133.71,63.59 133.78,63.53 133.78,63.41 133.82,63.37 v1(134.02,63.37)
  IN1 w0.119: 137.37,63.38 138.53,63.38 139.34,64.19 140.92,64.19 141.94,65.21 143.87,65.21 148.47,60.61 148.47,56.47 147.26,55.26 147.26,54.2 145.8,52.74 145.8,52.5 142.96,49.66 142.96,44.39 145.11,42.24 145.11,34.83 143.68,33.39 136.37,33.39 134.83,31.85 133.96,31.85 132.64,30.54 131.32,30.54 127.68,26.9 100.44,26.9 99.49,25.95 70.31,25.95 67.69,28.57 65.43,28.57 64.26,29.74 62.04,29.74 57.05,34.73 55.85,34.73 55.38,35.2 47.39,35.2 45.57,37.02 40.95,37.02 39.23,35.29 36.55,35.29 36.36,35.48 36.36,35.49 35.67,36.17 35.11,36.17 34.87,35.93 34.87,35.79 34.75,35.67 34.49,35.67 34.37,35.55 34.37,35.36 v1(34.5,35.24)
  BOTTOM w0.102: v1(134.02,63.37) 134.02,63.4 133.85,63.57 UC1.BJ5
  BOTTOM w0.112: JSSD1.19 34.87,34.8 34.87,34.81 34.87,34.87 v1(34.5,35.24)
PCIE_CRX_DTX_P15: length 173.3
  IN1 w0.089: v1(133.42,64.3) 133.56,64.44 133.56,64.68 133.74,64.87 135.63,64.87 136.18,64.32 136.88,64.32 136.89,64.33 136.91,64.33
  IN1 w0.119: v1(31.83,35.59) 31.83,34.68 32.07,34.43 39.59,34.43 40.14,34.99 46.38,34.99 47.03,34.33 54.98,34.33 55.45,33.86 56.69,33.86 62.85,27.71 67.33,27.71 69.95,25.09 99.85,25.09 100.8,26.04 128.04,26.04 131.55,29.56 133.75,29.56 136.6,32.41 139.03,32.41 139.52,32.41 144.78,32.41 145.97,33.6 145.97,42.97 146.71,43.71 146.71,52.43 148.13,53.84 148.13,54.9 149.33,56.11 149.33,60.97 144.23,66.07 141.56,66.07 140.53,65.05 138.98,65.05 138.27,64.33 136.91,64.33
  BOTTOM w0.076: UC1.BG6 v1(133.42,64.3)
  BOTTOM w0.112: v1(31.83,35.59) 32.01,35.41 32.01,34.7 31.87,34.57 JSSD1.31
