# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D33: length 51.1
  IN1 w0.119: v1(111.97,72.84) 111.47,73.34 104.17,73.34 103.5,72.66 96.9,72.66 93.91,69.67 91.26,69.67 85.76,64.18 74.53,64.18 74.26,64.45 73.19,64.45 v1(72.69,64.95)
  BOTTOM w0.076: UC1.AN34 115.63,73.47 115.55,73.4 115.55,73.24 115.87,72.93 115.87,72.74 115.83,72.7 115.66,72.53 115.59,72.46 115.07,72.46 114.69,72.6 114.45,72.6 114.33,72.56 114.15,72.56 114.04,72.6 112.91,72.6 112.76,72.46 112.46,72.46 112.07,72.84 v1(111.97,72.84)
  BOTTOM w0.112: JDIMM1.170 71.9,65.74 v1(72.69,64.95)
DDR_A_D34: length 53
  IN1 w0.089: 102.49,70.26 103.11,70.26 104.36,71.51 107.47,71.51 107.64,71.68 110.19,71.68 v1(111.34,72.84)
  IN1 w0.119: 102.49,70.26 97.66,70.26 94.02,66.61 91.43,66.61 85.45,60.63 73.13,60.63 73.04,60.72 73.04,61.19 73.12,61.27 73.62,61.27 v1(74.11,61.77)
  BOTTOM w0.076: UC1.AR35 115.12,72.27 114.66,72.44 114.48,72.44 114.36,72.4 114.12,72.4 114.01,72.44 112.98,72.44 112.83,72.29 112.39,72.29 112.21,72.47 111.71,72.47 v1(111.34,72.84)
  BOTTOM w0.112: v1(74.11,61.77) 73.14,62.74 JDIMM1.182
DDR_A_D35: length 53.4
  IN1 w0.089: 102.91,71.23 103.76,72.08 107.29,72.08 107.65,72.45 108.41,72.45 v1(108.8,72.84)
  IN1 w0.119: v1(72.59,61.77) 71.93,61.77 71.54,62.16 71.54,62.73 71.98,63.18 74.27,63.18 75.16,62.28 83.13,62.28 83.76,62.91 86.29,62.91 91.78,68.4 94.44,68.4 97.26,71.23 102.91,71.23
  BOTTOM w0.076: v1(108.8,72.84) 109.54,72.09 111.32,72.09 111.39,72.03 111.46,71.96 112,71.96 112.18,71.79 113.03,71.79 113.17,71.93 113.49,71.93 113.5,71.93 113.51,71.93 113.7,71.75 114.07,71.75 114.3,71.87 115.24,71.87 UC1.AR34
  BOTTOM w0.112: v1(72.59,61.77) 72.56,61.74 JDIMM1.186
DDR_A_D36: length 52.8
  IN1 w0.119: v1(75.74,64.95) 75.82,64.95 76.23,65.36 77.22,65.36 77.52,65.66 82.85,65.66 82.97,65.78 82.97,66 83.09,66.12 83.32,66.12 83.44,66 83.44,65.78 83.56,65.66 83.8,65.66 83.92,65.78 83.92,66 84.04,66.12 84.28,66.12 84.4,66 84.4,65.78 84.52,65.66 84.76,65.66 84.88,65.78 84.88,66 85,66.12 85.23,66.12 85.35,66 85.35,65.78 85.47,65.66 85.87,65.66 93.16,72.95 93.33,72.95 94.18,72.09 94.35,72.09 94.52,72.26 94.52,72.43 93.67,73.28 93.67,73.45 93.84,73.63 94.38,73.63 94.5,73.51 94.5,73.2 94.62,73.08 94.86,73.08 94.98,73.2 94.98,73.51 95.1,73.63 95.34,73.63 95.45,73.51 95.45,73.06 95.57,72.94 95.81,72.94 95.93,73.06 95.93,73.51 96.05,73.63 103.45,73.63 103.96,74.14 v1(109.89,74.14)
  BOTTOM w0.076: v1(109.89,74.14) 110.45,73.59 112.84,73.59 113.05,73.38 113.82,73.38 UC1.AN37
  BOTTOM w0.112: JDIMM1.169 76.51,65.99 75.74,65.22 v1(75.74,64.95)
DDR_A_D37: length 52.4
  IN1 w0.119: v1(77.26,64.95) 77.66,65.34 78.06,65.34 78.17,65.22 78.17,64.94 78.29,64.82 78.53,64.82 78.65,64.94 78.65,65.22 78.77,65.34 79.01,65.34 79.13,65.22 79.13,64.94 79.25,64.82 79.49,64.82 79.61,64.94 79.61,65.22 79.73,65.34 80.85,65.34 80.97,65.22 80.97,64.94 81.09,64.82 81.33,64.82 81.45,64.94 81.45,65.22 81.57,65.34 81.81,65.34 81.93,65.22 81.93,64.94 82.05,64.82 82.29,64.82 82.4,64.94 82.4,65.22 82.52,65.34 82.76,65.34 82.88,65.22 82.88,64.94 83,64.82 83.24,64.82 83.36,64.94 83.36,65.22 83.48,65.34 83.72,65.34 83.84,65.22 83.84,64.94 83.96,64.82 84.2,64.82 84.31,64.94 84.31,65.22 84.43,65.34 84.69,65.34 84.81,65.22 84.81,64.94 84.93,64.82 85.17,64.82 85.29,64.94 85.29,65.22 85.41,65.34 86.01,65.34 92.44,71.77 92.83,71.77 92.95,71.89 92.95,72.28 93.07,72.4 93.31,72.4 93.42,72.28 93.42,71.89 93.54,71.77 93.74,71.77 93.86,71.65 93.86,71.01 93.98,70.89 94.22,70.89 94.34,71.01 94.34,71.65 94.46,71.77 95.09,71.77 95.22,71.89 95.22,72.06 94.85,72.43 94.85,72.6 95.01,72.77 95.18,72.77 95.56,72.4 95.72,72.4 96.63,73.3 103.42,73.3 103.88,73.76 110.15,73.76 v1(110.53,74.14)
  BOTTOM w0.076: UC1.AN36 114.51,73.47 114.23,73.63 114.23,73.63 114.03,73.73 113.76,73.73 113.58,73.55 113.12,73.55 112.91,73.76 110.91,73.76 v1(110.53,74.14)
  BOTTOM w0.112: JDIMM1.173 77.31,64.99 v1(77.26,64.95)
DDR_A_D38: length 53.9
  IN1 w0.089: v1(109.43,72.84) 108.79,72.19 107.65,72.19 107.36,71.9 103.91,71.9 102.91,70.9
  IN1 w0.119: 102.91,70.9 97.4,70.9 94.58,68.08 91.95,68.08 85.83,61.96 85.66,61.96 85.22,62.4 85.05,62.4 84.88,62.24 84.88,62.07 85.32,61.62 85.32,61.45 85.15,61.28 84.48,61.28 84.36,61.4 84.36,62.46 84.24,62.58 84.01,62.58 83.89,62.46 83.89,61.4 83.77,61.28 83.53,61.28 83.41,61.4 83.41,61.84 83.29,61.96 83.05,61.96 82.93,61.84 82.93,61.4 82.81,61.28 82.57,61.28 82.45,61.4 82.45,61.84 82.33,61.96 82.1,61.96 81.98,61.84 81.98,61.58 81.86,61.46 81.62,61.46 81.5,61.58 81.5,61.84 81.38,61.96 81.14,61.96 81.02,61.84 81.02,61.4 80.9,61.28 79.25,61.28 79.13,61.4 79.13,61.84 79.01,61.96 77.81,61.96 77.69,61.84 77.69,61.4 77.57,61.28 76.89,61.28 76.77,61.4 76.77,61.65 76.89,61.77 v1(77.16,61.77)
  BOTTOM w0.076: v1(109.43,72.84) 110,72.27 111.43,72.27 111.57,72.14 112.06,72.14 112.07,72.13 112.25,71.95 112.96,71.95 113.11,72.1 113.57,72.1 113.76,71.91 114.03,71.91 114.26,72.04 114.26,72.04 114.51,72.17 UC1.AR36
  BOTTOM w0.112: JDIMM1.183 77.88,62.49 v1(77.16,61.77)
DDR_A_D39: length 53.3
  IN1 w0.089: v1(110.7,72.84) 109.73,71.86 107.57,71.86 107.39,71.69 104.05,71.69 102.94,70.58
  IN1 w0.119: 102.94,70.58 97.53,70.58 94.71,67.76 94.12,67.76 94,67.64 94,67.05 93.89,66.93 93.65,66.93 93.53,67.05 93.53,67.64 93.41,67.76 93.17,67.76 93.05,67.64 93.05,67.05 92.93,66.93 92.69,66.93 92.57,67.05 92.57,67.64 92.45,67.76 92.12,67.76 85.32,60.96 78.73,60.96 78.61,61.08 78.61,61.52 78.49,61.64 78.26,61.64 78.14,61.52 78.14,61.08 78.02,60.96 76.53,60.96 76.41,61.08 76.41,61.27 76.29,61.39 76.06,61.39 75.94,61.27 75.94,61.08 75.82,60.96 75.38,60.96 75.08,61.26 75.08,61.42 75.44,61.79 75.62,61.79 v1(75.64,61.77)
  BOTTOM w0.076: v1(110.7,72.84) 111.09,72.45 111.49,72.45 111.64,72.3 112.14,72.3 112.32,72.13 112.9,72.13 113.04,72.27 113.82,72.27 UC1.AR37
  BOTTOM w0.112: v1(75.64,61.77) 76.05,61.36 77.57,61.36 77.71,61.49 JDIMM1.187
DDR_A_D40: length 52.8
  IN1 w0.089: 102.86,69.04 103.17,69.04 104.87,70.75 107.4,70.75 107.55,70.6 110.49,70.6 v1(111.06,71.17)
  IN1 w0.119: v1(72.69,59.93) 73.96,58.66 75.62,58.66 75.74,58.54 75.74,58.24 75.86,58.12 77.12,58.12 77.24,58.24 77.24,58.75 77.36,58.87 77.93,58.87 78.05,58.75 78.05,58.24 78.17,58.12 79.93,58.12 80.05,58.24 80.05,58.36 80.22,58.53 80.59,58.53 81,58.12 85.04,58.12 90.69,63.76 93.28,63.76 98.28,68.76 102.58,68.76 102.86,69.04
  BOTTOM w0.076: UC1.AU35 115.04,70.78 114.89,70.78 114.66,70.7 114.48,70.7 114.36,70.74 114.12,70.74 114.02,70.7 114.01,70.7 112.98,70.7 112.83,70.85 111.91,70.85 111.85,70.79 111.45,70.79 v1(111.06,71.17)
  BOTTOM w0.112: v1(72.69,59.93) 72.5,59.74 JDIMM1.194
DDR_A_D41: length 53.2
  IN1 w0.089: 103.26,69.69 104.72,71.14 v1(107.87,71.14)
  IN1 w0.119: 103.26,69.69 102.68,69.69 102.4,69.41 98.02,69.41 94.33,65.72 93.78,65.72 93.63,65.57 93.63,65.02 93.01,64.4 90.42,64.4 85.53,59.51 84.1,59.51 83.35,58.76 83.1,58.76 82.98,58.88 82.98,59.37 82.87,59.48 82.63,59.48 82.51,59.37 82.51,58.88 82.39,58.76 82.15,58.76 82.03,58.88 82.03,59.39 81.91,59.51 81.67,59.51 81.55,59.39 81.55,58.88 81.43,58.76 81.26,58.76 80.51,59.51 76.16,59.51 v1(75.74,59.93)
  BOTTOM w0.076: v1(107.87,71.14) 108.46,71.74 111.36,71.74 111.38,71.72 111.92,71.72 112.29,71.35 113.03,71.35 113.18,71.19 113.5,71.19 113.69,71.39 114.07,71.39 114.32,71.25 115.26,71.25 115.47,71.15 115.67,71.15 UC1.AU34
  BOTTOM w0.112: JDIMM1.195 77.86,59.49 77.6,59.22 76.02,59.22 75.74,59.5 v1(75.74,59.93)
DDR_A_D42: length 54.5
  IN1 w0.089: 101.93,67.17 102.47,67.17 104.45,69.15 109.01,69.15 109.1,69.24 109.1,70.14 109.19,70.23 109.37,70.23 109.46,70.14 109.46,69.24 109.55,69.15 110.13,69.15 110.3,69.31 110.3,69.53 109.96,69.87 v1(109.84,69.87)
  IN1 w0.119: v1(75.74,56.82) 75.72,56.84 75.55,56.84 75.15,56.44 75.15,56.27 75.3,56.11 76.08,56.11 76.2,56.23 76.2,56.31 76.32,56.43 76.55,56.43 76.67,56.31 76.67,56.23 76.79,56.11 85.29,56.11 91.35,62.17 93.94,62.17 98.95,67.17 101.93,67.17
  BOTTOM w0.076: UC1.AW35 114.9,69.34 114.28,69.34 114.07,69.23 113.69,69.23 113.5,69.42 113.18,69.42 113,69.24 110.47,69.24 v1(109.84,69.87)
  BOTTOM w0.112: JDIMM1.207 77.91,56.49 77.6,56.18 76.38,56.18 v1(75.74,56.82)
DDR_A_D43: length 53.5
  IN1 w0.089: 103.21,69.36 104.78,70.92 107.48,70.92 107.62,70.78 109.4,70.78 v1(109.79,71.17)
  IN1 w0.119: 103.21,69.36 102.74,69.36 102.46,69.09 98.15,69.09 93.15,64.08 90.55,64.08 84.91,58.44 81.13,58.44 80.38,59.19 74.95,59.19 v1(74.22,59.93)
  BOTTOM w0.076: UC1.AW34 115.87,70.39 115.66,70.6 115.64,70.61 114.92,70.61 114.69,70.53 114.45,70.53 114.33,70.57 114.15,70.57 114.04,70.53 112.91,70.53 112.75,70.69 111.98,70.69 111.91,70.62 110.87,70.62 110.79,70.69 110.79,70.73 110.71,70.8 110.56,70.8 110.48,70.73 110.48,70.69 110.41,70.62 110.26,70.62 110.18,70.69 110.18,70.73 110.1,70.8 109.95,70.8 109.87,70.73 109.87,70.69 109.8,70.62 109.59,70.62 109.51,70.69 109.51,70.89 v1(109.79,71.17)
  BOTTOM w0.112: JDIMM1.190 73.4,60.74 v1(74.22,59.93)
DDR_A_D44: length 52.9
  IN1 w0.089: v1(111.7,71.17) 111.7,71.6 111.79,71.69 112.3,71.69 112.37,71.62 112.37,70.61 112.18,70.42 109.13,70.42 108.92,70.21 108.92,69.72 108.61,69.4 106.26,69.4 106.17,69.49 106.17,69.88 106.08,69.97 105.9,69.97 105.81,69.88 105.81,69.49 105.72,69.4 105.54,69.4 105.46,69.49 105.46,69.88 105.37,69.97 105.19,69.97 105.1,69.88 105.1,69.49 105.01,69.4 104.43,69.4
  IN1 w0.119: v1(77.26,56.82) 77.26,56.55 77.38,56.43 77.68,56.43 77.8,56.55 77.8,56.73 77.92,56.85 78.16,56.85 78.28,56.73 78.28,56.55 78.4,56.43 78.64,56.43 78.76,56.55 78.76,56.73 78.88,56.85 79.11,56.85 79.23,56.73 79.23,56.55 79.35,56.43 82.14,56.43 82.26,56.55 82.26,56.73 82.38,56.85 82.62,56.85 82.74,56.73 82.74,56.55 82.86,56.43 83.1,56.43 83.22,56.55 83.22,56.73 83.34,56.85 83.58,56.85 83.7,56.73 83.7,56.55 83.81,56.43 84.05,56.43 84.17,56.55 84.17,56.73 84.29,56.85 84.53,56.85 84.65,56.73 84.65,56.55 84.77,56.43 85.16,56.43 91.21,62.49 93.81,62.49 98.81,67.49 102.52,67.49 104.43,69.4
  BOTTOM w0.076: v1(111.7,71.17) 111.85,71.02 112.9,71.02 113.05,70.86 113.82,70.86 UC1.AU37
  BOTTOM w0.112: v1(77.26,56.82) 77.49,56.82 78.17,57.49 JDIMM1.203
DDR_A_D45: length 52.4
  IN1 w0.089: 103.28,69.98 104.64,71.33 107.54,71.33 107.72,71.51 108.82,71.51 v1(109.16,71.17)
  IN1 w0.119: 103.28,69.98 102.59,69.98 102.35,69.73 97.88,69.73 94.24,66.09 93.49,66.09 93.31,65.91 93.31,65.16 93.19,65.04 92.95,65.04 92.83,65.16 92.83,65.97 92.71,66.09 92.47,66.09 92.35,65.97 92.35,64.85 92.23,64.73 91.99,64.73 91.87,64.85 91.87,65.9 91.75,66.02 91.58,66.02 91.35,65.79 91.35,64.85 91.23,64.73 90.29,64.73 85.39,59.84 84.31,59.84 84.19,59.95 84.19,59.99 84.07,60.11 83.83,60.11 83.71,59.99 83.71,59.57 83.59,59.45 83.35,59.45 83.23,59.57 83.23,59.99 83.11,60.11 82.87,60.11 82.75,59.99 82.75,59.95 82.63,59.84 82.4,59.84 82.28,59.95 82.28,59.99 82.16,60.11 81.92,60.11 81.8,59.99 81.8,59.95 81.68,59.84 81.44,59.84 81.32,59.95 81.32,59.99 81.2,60.11 80.96,60.11 80.84,59.99 80.84,59.95 80.72,59.84 80.49,59.84 80.37,59.95 80.37,59.99 80.25,60.11 80.01,60.11 79.89,59.99 79.89,59.95 79.77,59.84 79.53,59.84 79.41,59.95 79.41,59.99 79.29,60.11 79.05,60.11 78.93,59.99 78.93,59.95 78.81,59.84 78.58,59.84 78.46,59.95 78.46,59.99 78.34,60.11 78.1,60.11 77.98,59.99 77.98,59.95 77.86,59.84 77.36,59.84 v1(77.26,59.93)
  BOTTOM w0.076: v1(109.16,71.17) 109.54,71.56 111.3,71.56 111.31,71.55 111.85,71.55 112.23,71.18 112.96,71.18 113.11,71.03 113.57,71.03 113.76,71.22 114.03,71.22 114.27,71.09 114.28,71.08 114.44,71.08 UC1.AU36
  BOTTOM w0.112: v1(77.26,59.93) 77.26,60.09 77.67,60.49 JDIMM1.191
DDR_A_D46: length 53.7
  IN1 w0.089: v1(111.11,69.87) 110.13,68.89 104.45,68.89 102.4,66.85 102.19,66.85
  IN1 w0.119: 102.19,66.85 102.18,66.85 99.08,66.85 94.07,61.84 91.48,61.84 85.43,55.79 73.05,55.79 72.93,55.91 72.93,56.31 73.05,56.43 73.84,56.43 73.96,56.55 73.96,56.56 v1(74.22,56.82)
  BOTTOM w0.076: v1(111.11,69.87) 110.97,69.73 110.97,69.49 111.05,69.41 112.95,69.41 113.12,69.58 113.57,69.58 113.76,69.39 114.03,69.39 114.51,69.66 UC1.AW36
  BOTTOM w0.112: v1(74.22,56.82) 73.64,56.24 JDIMM1.208
DDR_A_D47: length 52.6
  IN1 w0.089: v1(111.74,69.87) 110.57,68.7 104.62,68.7 102.44,66.53 102.18,66.53
  IN1 w0.119: 102.18,66.53 99.21,66.53 94.21,61.52 91.62,61.52 85.56,55.46 71.78,55.46 71.6,55.65 71.6,56.57 71.84,56.82 v1(72.69,56.82)
  BOTTOM w0.076: UC1.AW37 113.82,69.75 113.05,69.75 112.89,69.59 112.02,69.59 v1(111.74,69.87)
  BOTTOM w0.112: JDIMM1.204 72.27,57.24 v1(72.69,56.82)
DDR_A_D48: length 53.4
  IN1 w0.089: 102.99,65.55 104.92,67.48 109,67.48 v1(109.72,68.21)
  IN1 w0.119: v1(75.74,54.19) 76.65,53.27 81.82,53.27 81.94,53.15 81.94,52.84 82.06,52.72 82.3,52.72 82.42,52.84 82.42,53.15 82.54,53.27 82.78,53.27 82.9,53.15 82.9,52.84 83.01,52.72 83.25,52.72 83.37,52.84 83.37,53.15 83.49,53.27 83.73,53.27 83.85,53.15 83.85,52.84 83.97,52.72 84.21,52.72 84.33,52.84 84.33,53.15 84.45,53.27 84.69,53.27 84.81,53.15 84.81,53.01 84.92,52.89 85.16,52.89 85.28,53.01 85.28,53.15 85.4,53.27 86.67,53.27 93.43,60.03 94.83,60.03 99.63,64.83 102.27,64.83 102.99,65.55
  BOTTOM w0.076: UC1.BA35 115.12,68.34 114.66,68.18 114.48,68.18 114.36,68.22 114.12,68.22 114.01,68.18 112.91,68.18 112.67,68.41 111.88,68.41 111.37,67.9 110.03,67.9 v1(109.72,68.21)
  BOTTOM w0.112: JDIMM1.211 77.04,55.49 v1(75.74,54.19)
DDR_A_D49: length 53.5
  IN1 w0.089: 102.3,66 104.49,68.2 v1(106.47,68.2)
  IN1 w0.119: v1(72.69,54.19) 73.45,54.94 85.78,54.94 86.25,55.42 86.42,55.42 86.73,55.11 86.9,55.11 87.07,55.28 87.07,55.45 86.76,55.75 86.76,55.92 86.93,56.09 87.1,56.09 87.4,55.78 87.57,55.78 87.74,55.95 87.74,56.12 87.44,56.43 87.44,56.6 91.83,60.99 94.43,60.99 99.43,66 102.3,66
  BOTTOM w0.076: UC1.BA34 115.22,68.76 114.28,68.76 114.07,68.87 113.68,68.87 113.49,68.68 113.1,68.68 112.84,68.95 107.22,68.95 v1(106.47,68.2)
  BOTTOM w0.112: v1(72.69,54.19) 72.64,54.24 JDIMM1.216
DDR_A_D50: length 53.9
  IN1 w0.089: v1(105.38,66.54) 101.89,63.05
  IN1 w0.119: 101.89,63.05 100.88,63.05 99.98,62.14 99.44,62.14 95.73,58.43 94.66,58.43 91.66,55.43 91.49,55.43 91.37,55.55 91.2,55.55 91.03,55.38 91.03,55.21 91.38,54.87 91.38,54.7 91.22,54.54 91.03,54.54 90.7,54.87 90.53,54.87 90.36,54.7 90.36,54.54 90.72,54.17 90.72,54 90.55,53.83 90.39,53.83 90.02,54.2 89.85,54.2 89.68,54.03 89.68,53.86 90.05,53.49 90.05,53.33 89.88,53.16 89.71,53.16 89.34,53.52 89.18,53.52 89.01,53.35 89.01,53.18 89.37,52.82 89.37,52.65 89.2,52.48 89.03,52.48 88.67,52.85 88.5,52.85 88.33,52.68 88.33,52.51 88.7,52.14 88.7,51.97 88.53,51.8 88.36,51.8 87.99,52.17 87.82,52.17 86.69,51.04 v1(77.08,51.04)
  BOTTOM w0.076: v1(105.38,66.54) 105.38,66.5 105.99,65.89 106.72,65.89 106.8,65.8 110.47,65.8 111.4,66.74 113.03,66.74 113.19,66.9 113.49,66.9 113.68,66.71 114.07,66.71 114.28,66.82 114.9,66.82 UC1.BC35
  BOTTOM w0.112: v1(77.08,51.04) 77.12,50.99 JDIMM1.229
DDR_A_D51: length 54
  IN1 w0.089: v1(107.82,66.54) 107.06,65.78 105.63,65.78 102.29,62.43 101.4,62.43
  IN1 w0.119: v1(72.5,51.04) 73.25,50.29 86.85,50.29 87.73,51.16 88.79,51.16 92.02,54.39 92.02,54.88 94.93,57.79 96,57.79 97.99,59.78 98.75,59.78 101.4,62.43
  BOTTOM w0.076: v1(107.82,66.54) 109.01,67.73 111.44,67.73 111.94,68.24 112.61,68.24 112.84,68.01 114.04,68.01 114.15,68.05 114.33,68.05 114.45,68.01 114.69,68.01 114.94,68.1 115.64,68.1 115.66,68.08 115.87,67.87 UC1.BC34
  BOTTOM w0.112: v1(72.5,51.04) 72.5,51.13 72.39,51.24 JDIMM1.228
DDR_A_D52: length 51.8
  IN1 w0.089: v1(108.45,68.21) 107.9,67.66 104.68,67.66 102.59,65.57
  IN1 w0.119: 102.59,65.57 102.18,65.15 99.5,65.15 94.69,60.35 93.29,60.35 86.6,53.65 86.25,53.65 86.13,53.77 86.13,54.04 86.01,54.16 85.77,54.16 85.65,54.04 85.65,53.77 85.53,53.65 85.29,53.65 85.17,53.77 85.17,54.17 85.05,54.29 84.81,54.29 84.69,54.17 84.69,53.77 84.57,53.65 84.22,53.65 84.1,53.77 84.1,54.17 83.99,54.29 83.75,54.29 83.63,54.17 83.63,53.77 83.51,53.65 83.27,53.65 83.15,53.77 83.15,54.17 83.03,54.29 82.79,54.29 82.67,54.17 82.67,53.77 82.55,53.65 82.31,53.65 82.19,53.77 82.19,54.17 82.08,54.29 81.84,54.29 81.72,54.17 81.72,53.77 81.6,53.65 77.8,53.65 v1(77.26,54.19)
  BOTTOM w0.076: v1(108.45,68.21) 108.84,68.59 110.12,68.59 110.2,68.52 110.2,68.14 110.27,68.07 110.43,68.07 110.5,68.14 110.5,68.52 110.58,68.59 110.73,68.59 110.81,68.52 110.81,68.13 110.88,68.06 111.04,68.06 111.11,68.13 111.11,68.52 111.19,68.59 111.36,68.59 111.49,68.46 111.65,68.46 111.78,68.59 112.72,68.59 112.97,68.35 113.83,68.35 UC1.BA37
  BOTTOM w0.112: JDIMM1.215 77.57,54.49 v1(77.26,54.19)
DDR_A_D53: length 52.8
  IN1 w0.089: v1(107.82,68.21) 107.45,67.84 104.51,67.84 102.33,65.65
  IN1 w0.119: 102.33,65.65 99.54,65.65 94.56,60.67 91.97,60.67 90.72,59.42 90.65,59.36 90.65,59.19 91.08,58.76 91.08,58.6 90.91,58.43 90.74,58.43 90.32,58.85 90.15,58.85 89.98,58.68 89.98,58.52 90.41,58.09 90.41,57.92 87.1,54.62 74.65,54.62 v1(74.22,54.19)
  BOTTOM w0.076: UC1.BA36 114.51,68.44 114.24,68.59 114.23,68.59 114.03,68.7 113.76,68.7 113.58,68.52 113.03,68.52 112.78,68.77 108.38,68.77 v1(107.82,68.21)
  BOTTOM w0.112: v1(74.22,54.19) 73.16,55.24 JDIMM1.212
DDR_A_D54: length 52.5
  IN1 w0.089: v1(106.55,66.54) 106.04,66.04 105.52,66.04 102.33,62.84
  IN1 w0.119: v1(74.03,51.04) 73.95,50.96 73.95,50.73 74.06,50.62 86.73,50.62 87.8,51.69 87.97,51.69 88.18,51.48 88.66,51.48 91.7,54.52 91.7,55.02 94.79,58.11 95.87,58.11 99.58,61.82 100.11,61.82 101.13,62.84 102.33,62.84
  BOTTOM w0.076: v1(106.55,66.54) 107.12,65.98 110.41,65.98 111.33,66.9 112.96,66.9 113.12,67.06 113.56,67.06 113.75,66.87 114.03,66.87 114.51,67.14 UC1.BC36
  BOTTOM w0.112: v1(74.03,51.04) 72.83,52.24 JDIMM1.224
DDR_A_D55: length 51.7
  IN1 w0.089: v1(107.19,66.54) 106.8,66.93 105.26,66.93 101.63,63.3 101.17,63.3
  IN1 w0.119: v1(75.55,51.04) 75.47,51.12 75.47,51.37 75.56,51.45 86.65,51.45 91.35,56.15 91.92,56.15 92.31,56.54 92.31,56.71 92.19,56.83 92.19,57 92.36,57.16 92.53,57.16 92.65,57.05 92.82,57.05 92.99,57.22 92.99,57.39 92.87,57.5 92.87,57.67 93.04,57.84 93.21,57.84 93.32,57.72 93.49,57.72 93.66,57.89 93.66,58.06 93.54,58.18 93.54,58.35 93.71,58.52 93.88,58.52 94,58.4 94.17,58.4 94.53,58.76 95.6,58.76 99.41,62.57 99.58,62.57 99.68,62.47 99.84,62.47 100.68,63.3 101.17,63.3
  BOTTOM w0.076: v1(107.19,66.54) 107.57,66.16 110.35,66.16 111.26,67.07 112.89,67.07 113.06,67.24 113.82,67.24 UC1.BC37
  BOTTOM w0.112: JDIMM1.225 76.5,51.99 v1(75.55,51.04)
DDR_A_D56: length 57.6
  IN1 w0.119: v1(111.33,65.06) 111.33,64.87 110.55,64.09 105.59,64.09 102.69,61.19 102.27,61.19 97.12,56.04 96.96,56.04 96.71,56.3 96.47,56.3 96.3,56.12 96.3,55.95 96.54,55.71 96.54,55.54 96.37,55.37 96.2,55.37 95.96,55.61 95.79,55.61 95.56,55.39 95.56,55.22 95.61,55.17 95.61,55 95.45,54.83 95.28,54.83 95.23,54.88 95.06,54.88 94.72,54.54 94.29,54.54 91.31,51.56 91.31,51.39 91.67,51.02 91.67,50.86 91.5,50.69 91.34,50.69 90.97,51.05 90.8,51.05 90.63,50.88 90.63,50.71 91,50.35 91,50.18 90.83,50.01 90.66,50.01 90.29,50.38 90.13,50.38 89.96,50.21 89.96,50.04 90.32,49.67 90.32,49.5 88.94,48.12 75.12,48.12 v1(74.22,49.02)
  BOTTOM w0.076: v1(111.33,65.06) 111.39,65.17 112.04,65.82 112.83,65.82 112.99,65.66 114.01,65.66 114.12,65.7 114.36,65.7 114.48,65.66 114.66,65.66 115.12,65.83 UC1.BE35
  BOTTOM w0.112: v1(74.22,49.02) 73,50.24 JDIMM1.232
DDR_A_D57: length 57.6
  IN1 w0.119: v1(75.74,49.02) 75.62,49.15 75.62,49.32 75.74,49.44 77.68,49.44 77.8,49.32 77.8,48.94 77.92,48.82 78.16,48.82 78.28,48.94 78.28,49.32 78.4,49.44 78.64,49.44 78.87,49.21 79.12,49.21 79.35,49.44 81.69,49.44 81.81,49.32 81.81,48.95 81.93,48.83 82.17,48.83 82.29,48.95 82.29,49.32 82.4,49.44 82.64,49.44 82.76,49.32 82.76,48.95 82.88,48.83 83.12,48.83 83.24,48.95 83.24,49.32 83.36,49.44 83.6,49.44 83.72,49.32 83.72,48.95 83.84,48.83 84.08,48.83 84.2,48.95 84.2,49.32 84.32,49.44 84.55,49.44 84.67,49.32 84.67,48.95 84.79,48.83 85.03,48.83 85.15,48.95 85.15,49.32 85.27,49.44 85.63,49.44 85.75,49.32 85.75,48.95 85.87,48.83 86.11,48.83 86.23,48.95 86.23,49.32 86.35,49.44 87.21,49.44 88.08,50.31 89.15,50.31 94.02,55.19 94.45,55.19 96.2,56.94 97.11,56.94 102.01,61.84 102.42,61.84 104.24,63.65 104.24,63.73 105.43,64.92 v1(108.15,64.92)
  BOTTOM w0.076: v1(108.15,64.92) 108.67,65.45 110.34,65.45 111.27,66.37 112.98,66.37 113.19,66.16 113.49,66.16 113.68,66.35 114.07,66.35 114.32,66.22 115.26,66.22 UC1.BE34
  BOTTOM w0.112: JDIMM1.233 76.71,49.99 v1(75.74,49.02)
DDR_A_D58: length 58.3
  IN1 w0.119: v1(109.82,63.61) 109.15,62.94 108.28,62.94 105.56,60.22 105.56,59.44 104.59,58.47 103.46,58.47 103.2,58.21 103.2,58.04 103.22,58.01 103.22,57.85 103.05,57.68 102.89,57.68 102.84,57.72 102.67,57.72 102.5,57.55 102.5,57.39 102.95,56.93 102.95,56.77 102.78,56.6 102.61,56.6 102.16,57.05 101.99,57.05 101.83,56.88 101.83,56.71 102.22,56.31 102.22,56.15 102.05,55.98 101.88,55.98 101.49,56.37 101.32,56.37 99.74,54.8 99.6,54.8 99.18,55.22 99.01,55.22 98.36,54.57 98.36,54.41 98.58,54.19 98.58,54.02 98.41,53.86 98.24,53.86 98.03,54.07 97.86,54.07 97.34,53.55 97.34,53.32 97.51,53.15 97.51,52.95 90.42,45.87 88.95,45.87 88.6,45.52 74.96,45.52 v1(74.22,46.27)
  BOTTOM w0.076: UC1.BG35 114.9,64.3 114.27,64.3 114.07,64.19 113.68,64.19 113.49,64.38 113.19,64.38 112.6,63.8 110.01,63.8 v1(109.82,63.61)
  BOTTOM w0.112: JDIMM1.250 72.01,45.74 72.24,45.51 73.46,45.51 v1(74.22,46.27)
DDR_A_D59: length 58.3
  IN1 w0.119: v1(111.97,65.13) 111.97,65.05 109.53,62.61 108.41,62.61 105.98,60.19 105.98,59.4 104.73,58.15 103.79,58.15 103.67,58.03 103.67,57.79 103.41,57.53 103.41,56.7 102,55.28 101.83,55.28 101.34,55.77 101.17,55.77 101,55.6 101,55.43 101.42,55.02 101.42,54.83 101.26,54.68 101.08,54.68 100.67,55.09 100.5,55.09 100.21,54.81 100.21,54.64 100.29,54.57 100.29,54.4 100.12,54.23 99.95,54.23 99.88,54.3 99.71,54.3 99.46,54.06 99.07,54.06 90.56,45.55 89.09,45.55 88.73,45.2 73.76,45.2 v1(72.69,46.27)
  BOTTOM w0.076: v1(111.97,65.13) 111.99,65.19 112.45,65.65 112.76,65.65 112.92,65.49 114.04,65.49 114.15,65.54 114.33,65.54 114.45,65.49 114.69,65.49 114.9,65.57 115.65,65.57 115.66,65.56 115.83,65.39 115.83,65.39 115.87,65.36 UC1.BG34
  BOTTOM w0.112: JDIMM1.246 71.92,46.74 72.39,46.27 v1(72.69,46.27)
DDR_A_D60: length 56.4
  IN1 w0.119: v1(77.26,49.02) 77.01,49.02 76.86,48.88 76.86,48.56 76.98,48.44 78.43,48.44 78.55,48.56 78.55,48.77 78.67,48.89 78.91,48.89 79.03,48.77 79.03,48.56 79.15,48.44 79.44,48.44 79.56,48.56 79.56,49 79.68,49.12 79.92,49.12 80.04,49 80.04,48.56 80.16,48.44 80.79,48.44 80.91,48.56 80.91,49 81.03,49.12 81.26,49.12 81.38,49 81.38,48.56 81.5,48.44 86.43,48.44 86.55,48.56 86.55,49 86.67,49.12 86.91,49.12 87.03,49 87.03,48.56 87.15,48.44 87.73,48.44 87.85,48.56 87.85,48.73 87.54,49.04 87.54,49.21 87.71,49.38 87.88,49.38 88.73,48.53 88.9,48.53 89.1,48.74 89.1,48.91 88.29,49.73 88.29,49.88 88.4,49.99 88.79,49.99 89.48,49.29 89.65,49.29 89.87,49.5 89.87,49.67 89.5,50.04 89.5,50.21 94.16,54.86 94.58,54.86 96.34,56.62 97.24,56.62 102.14,61.52 102.56,61.52 105.51,64.47 109.58,64.47 v1(109.98,64.87)
  BOTTOM w0.076: v1(109.98,64.87) 109.98,65 110.08,65.1 110.47,65.1 111.35,65.98 112.9,65.98 113.06,65.83 113.82,65.83 UC1.BE37
  BOTTOM w0.112: v1(77.26,49.02) 77.26,49.35 77.38,49.46 77.95,49.46 78.42,48.99 JDIMM1.237
DDR_A_D61: length 56.4
  IN1 w0.089: 103.3,63.18 103.41,63.18 105.57,65.34 108.92,65.34 v1(109.37,64.88)
  IN1 w0.119: 103.3,63.18 102.29,62.16 101.87,62.16 98.59,58.88 98.42,58.88 98.21,59.09 98.05,59.09 97.88,58.92 97.88,58.75 98.09,58.54 98.09,58.38 97.92,58.21 97.75,58.21 97.54,58.41 97.37,58.41 97.2,58.25 97.2,58.08 97.41,57.87 97.41,57.7 96.97,57.26 95.15,57.26 94.04,56.16 94.04,55.99 94.18,55.85 94.18,55.68 94.02,55.51 93.85,55.51 93.7,55.65 93.53,55.65 93.36,55.48 93.36,55.31 93.44,55.23 93.44,55.06 93.27,54.89 93.1,54.89 93.02,54.97 92.85,54.97 92.68,54.8 92.68,54.63 92.76,54.55 92.76,54.38 89.01,50.63 87.94,50.63 87.07,49.76 72.21,49.76 72.09,49.64 72.09,48.82 72.21,48.7 72.53,48.7 72.69,48.87 v1(72.69,49.02)
  BOTTOM w0.076: UC1.BE36 114.51,65.92 114.03,66.19 113.75,66.19 113.56,66 113.12,66 112.91,66.2 111.34,66.2 110.4,65.27 109.87,65.27 v1(109.37,64.88)
  BOTTOM w0.112: v1(72.69,49.02) 72.28,49.02 72.07,49.24 JDIMM1.236
DDR_A_D62: length 57.5
  IN1 w0.119: v1(109.19,63.62) 108.83,63.26 108.14,63.26 104.64,59.75 104.64,59.57 104.41,59.34 103.53,59.34 103.41,59.22 103.41,58.92 100.05,55.56 98.9,55.56 97.54,54.2 96.86,53.53 96.86,53.36 97.06,53.16 97.06,52.99 96.89,52.83 96.72,52.83 96.52,53.02 96.36,53.02 96.19,52.85 96.19,52.68 96.38,52.49 96.38,52.32 96.21,52.15 96.05,52.15 95.85,52.35 95.68,52.35 95.51,52.18 95.51,52.01 95.71,51.81 95.71,51.64 95.54,51.47 95.37,51.47 95.17,51.67 95,51.67 94.83,51.5 94.83,51.33 95.03,51.14 95.03,50.97 94.86,50.8 94.69,50.8 94.5,50.99 94.33,50.99 94.16,50.83 94.16,50.66 94.36,50.46 94.36,50.29 94.19,50.12 94.02,50.12 93.82,50.32 93.65,50.32 93.48,50.15 93.48,49.98 93.68,49.78 93.68,49.62 93.51,49.45 93.34,49.45 93.15,49.64 92.98,49.64 92.81,49.47 92.81,49.31 93,49.11 93,48.94 92.84,48.77 92.67,48.77 92.47,48.97 92.3,48.97 92.13,48.8 92.13,48.63 92.33,48.43 92.33,48.26 92.16,48.1 91.99,48.1 91.79,48.29 91.63,48.29 91.46,48.12 91.46,47.95 91.65,47.76 91.65,47.59 90.26,46.19 88.82,46.19 88.47,45.84 76.16,45.84 v1(75.74,46.27)
  BOTTOM w0.076: v1(109.19,63.62) 109.53,63.96 112.53,63.96 113.12,64.55 113.56,64.55 113.75,64.36 114.03,64.36 114.27,64.49 UC1.BG36
  BOTTOM w0.112: v1(75.74,46.27) 76.46,46.99 JDIMM1.245
DDR_A_D63: length 56.9
  IN1 w0.119: v1(108.11,63.64) 108.06,63.64 104.62,60.19 103.49,60.19 103.09,59.8 103.09,59.06 99.92,55.88 98.76,55.88 96.12,53.24 95.95,53.24 95.69,53.5 95.52,53.5 95.25,53.24 95.25,53.07 95.38,52.94 95.38,52.77 90.78,48.17 90.78,48 90.94,47.83 90.94,47.66 90.76,47.47 90.59,47.47 90.42,47.64 90.25,47.64 90.08,47.47 90.08,47.3 90.41,46.97 90.41,46.8 90.24,46.63 90.07,46.63 89.75,46.96 89.58,46.96 89.46,46.85 88.33,46.85 88.21,46.73 88.21,46.28 88.09,46.17 87.85,46.17 87.73,46.28 87.73,46.73 87.61,46.85 87.37,46.85 87.25,46.73 87.25,46.28 87.13,46.17 86.89,46.17 86.77,46.28 86.77,46.73 86.65,46.85 86.42,46.85 86.3,46.73 86.3,46.28 86.18,46.17 85.94,46.17 85.82,46.28 85.82,46.73 85.7,46.85 85.41,46.85 85.29,46.73 85.29,46.28 85.17,46.17 84.93,46.17 84.81,46.28 84.81,46.73 84.69,46.85 84.45,46.85 84.33,46.73 84.33,46.28 84.21,46.17 83.97,46.17 83.85,46.28 83.85,46.73 83.73,46.85 83.5,46.85 83.38,46.73 83.38,46.28 83.26,46.17 83.02,46.17 82.9,46.28 82.9,46.73 82.78,46.85 82.54,46.85 82.42,46.73 82.42,46.28 82.3,46.17 82.06,46.17 81.94,46.28 81.94,46.73 81.82,46.85 81.52,46.85 80.94,46.27 v1(77.26,46.27)
  BOTTOM w0.076: v1(108.11,63.64) 108.62,64.14 112.48,64.14 113.05,64.71 113.83,64.71 UC1.BG37
  BOTTOM w0.112: v1(77.26,46.27) 77.54,45.99 79.15,45.99 JDIMM1.249
DDR_A_DQS0: length 66.1
  IN1 w0.089: 112.81,95.44 113.7,94.55 119.28,94.55 120.75,96.02 120.75,97.73 120.86,97.83 120.86,98.45 v1(121.12,98.71)
  IN1 w0.119: v1(74.6,102.02) 74.58,102.02 74.46,102.14 74.46,102.32 74.58,102.43 86.38,102.43 88.78,100.04 103.47,100.04 108.07,95.44 112.81,95.44
  BOTTOM w0.076: UC1.D27 120.18,91 120.18,91.15 120.54,91.32 120.61,91.51 120.61,91.78 120.57,91.88 120.57,92.06 120.61,92.18 120.61,92.42 120.57,92.53 120.57,93.55 120.72,93.7 120.72,94.16 120.57,94.31 120.57,96.95 120.57,97.02 120.64,97.09 120.64,98.06 120.91,98.33 120.91,98.5 v1(121.12,98.71)
  BOTTOM w0.112: v1(74.6,102.02) 74.53,102.02 74.29,101.78 74.29,101.58 74.05,101.33 72.72,101.33 72.19,101.86 72.03,101.86 71.91,101.74 JDIMM1.34
DDR_A_DQS1: length 64.3
  IN1 w0.119: v1(118.14,100.8) 117.4,100.8 117.24,100.97 117.24,102.26 115.29,104.21 110.59,104.21 110.34,103.96 110.34,103.01 110.22,102.89 106.5,102.89 106.09,103.3 106.09,103.96 105.84,104.21 93.02,104.21 89.48,107.75 77.69,107.75 77.69,107.75 77.61,107.75 77.17,108.2 75.68,108.2 75.43,107.95 v1(75.43,107.23)
  BOTTOM w0.076: v1(118.14,100.8) 117.93,100.59 117.78,100.59 117.59,100.4 117.59,98.65 117.49,98.55 117.49,94.64 118.04,94.09 118.04,93.78 117.89,93.62 117.89,92.5 117.93,92.39 117.93,92.21 117.89,92.09 117.89,91.85 117.93,91.75 117.93,91.55 117.89,91.44 117.79,91.4 117.71,91.43 117.66,91.47 UC1.C31
  BOTTOM w0.112: JDIMM1.13 78.12,106.99 77.98,107.13 77.83,107.13 77.3,106.6 75.93,106.6 75.69,106.84 75.69,107.09 75.55,107.23 v1(75.43,107.23)
DDR_A_DQS2: length 52
  IN1 w0.089: v1(109.14,91.91) 109.43,92.21 109.43,92.36 109.34,92.45 107.86,92.45 107.67,92.26 106.57,92.26 102.69,96.15 102.18,96.15 102.16,96.13 102.14,96.13
  IN1 w0.119: v1(76.18,96.75) 75.94,96.98 75.77,96.98 75.63,97.12 75.63,97.31 75.75,97.43 77.1,97.43 77.7,96.83 81.09,96.83 81.79,96.13 102.14,96.13
  BOTTOM w0.076: v1(109.14,91.91) 109.38,91.67 109.38,91.43 109.56,91.25 110.71,91.25 111.03,90.94 111.03,90.62 111.97,89.68 111.97,87.78 112.37,87.38 112.76,87.38 112.83,87.38 112.99,87.54 114.01,87.54 114.12,87.5 114.36,87.5 114.48,87.54 114.67,87.54 114.8,87.49 115,87.49 115.25,87.58 115.3,87.72 115.3,87.85 115.38,87.93 UC1.J34
  BOTTOM w0.112: JDIMM1.55 78.32,96.49 78.2,96.61 77.82,96.61 77.08,97.35 76.08,97.35 75.82,97.09 75.82,96.94 76.01,96.75 v1(76.18,96.75)
DDR_A_DQS3: length 51.5
  IN1 w0.089: 102.14,92.62 102.16,92.62 102.18,92.6 102.44,92.6 106.23,88.81 108.51,88.81 108.86,88.47 108.86,88.1 108.97,87.99 v1(109.1,87.99)
  IN1 w0.119: 102.14,92.62 87.31,92.62 85.44,90.75 75.49,90.75 75.35,90.62 74.35,90.62 74.21,90.75 74.21,91.07 74.39,91.24 74.53,91.24 v1(74.57,91.28)
  BOTTOM w0.076: UC1.P35 115.07,85.41 115.14,85.34 115.14,85.25 115.11,85.2 114.93,85.14 114.83,85.14 114.69,85.19 114.45,85.19 114.33,85.15 114.15,85.15 114.04,85.19 112.92,85.19 112.76,85.03 112.45,85.03 110.06,87.43 109.04,87.43 108.87,87.59 108.87,87.87 108.99,87.99 v1(109.1,87.99)
  BOTTOM w0.112: JDIMM1.76 71.83,91.24 71.91,91.32 72.06,91.32 72.88,90.5 74.08,90.5 74.3,90.72 74.3,91.01 v1(74.57,91.28)
DDR_A_DQS4: length 53.6
  IN1 w0.089: v1(106.87,72.84) 107.09,72.84 107.18,72.75 107.18,72.54 107.09,72.45 103.61,72.45 103.59,72.46 103.42,72.46 103.38,72.42 103.37,72.42 103.36,72.42 103.35,72.41
  IN1 w0.119: v1(75.98,63.65) 75.79,63.65 75.56,63.43 75.56,63.14 75.68,63.03 77.64,63.03 77.76,63.14 77.76,63.4 78,63.65 78.54,63.65 78.79,63.4 78.79,63.14 78.91,63.03 79.27,63.03 79.39,63.14 79.39,63.4 79.63,63.65 80.17,63.65 80.42,63.4 80.42,63.14 80.54,63.03 81.11,63.03 81.23,63.14 81.23,63.25 81.48,63.5 82.02,63.5 82.26,63.25 82.26,63.14 82.38,63.03 82.82,63.03 83.45,63.65 85.98,63.65 91.48,69.15 94.13,69.15 96.95,71.97 102.9,71.97 103.35,72.41
  BOTTOM w0.076: v1(106.87,72.84) 107.02,72.84 107.27,73.08 107.27,73.48 107.44,73.66 108.28,73.66 108.54,73.39 112.79,73.39 112.98,73.21 114.01,73.21 114.14,73.26 114.35,73.26 114.48,73.21 114.66,73.21 114.8,73.27 114.98,73.27 115.23,73.18 115.54,72.86 UC1.AP34
  BOTTOM w0.112: v1(75.98,63.65) 75.75,63.65 75.54,63.86 75.54,64.17 75.66,64.29 76.92,64.29 77.44,63.77 77.93,63.77 78.21,63.49 JDIMM1.179
DDR_A_DQS5: length 53.1
  IN1 w0.089: v1(107.29,69.87) 107.41,69.98 107.41,70.22 107.34,70.29 104.94,70.29 103.14,68.49 102.99,68.44 102.97,68.42
  IN1 w0.119: v1(73.84,58.14) 74.04,58.14 74.2,57.97 74.2,57.62 74.45,57.37 85.35,57.37 91,63.01 93.59,63.01 98.59,68.02 102.57,68.02 102.8,68.25 102.8,68.25 102.97,68.42
  BOTTOM w0.076: v1(107.29,69.87) 107.49,70.07 107.49,70.29 107.65,70.44 111.94,70.44 112.45,69.93 112.76,69.93 112.91,70.09 114.04,70.09 114.15,70.04 114.33,70.04 114.45,70.09 114.69,70.09 114.78,70.05 115,70.05 115.1,70.09 115.12,70.13 115.12,70.25 115.06,70.31 UC1.AV35
  BOTTOM w0.112: v1(73.84,58.14) 73.99,58.14 74.2,58.35 74.2,58.73 74.08,58.86 72.85,58.86 72.37,58.38 72.12,58.38 71.98,58.24 JDIMM1.200
DDR_A_DQS6: length 52.7
  IN1 w0.089: v1(109.63,66.54) 109.72,66.63 109.72,66.76 109.62,66.86 109.32,66.86 109.22,66.96 109.22,67.09 109.21,67.1 109.2,67.1 109.01,67.29 105.1,67.29 101.99,64.18 100.59,64.18 100.57,64.21 100.51,64.21 100.5,64.22 100.48,64.22
  IN1 w0.119: 100.48,64.22 99.77,64.22 95.05,59.5 93.65,59.5 86.34,52.2 75.9,52.2 75.75,52.35 75.75,52.56 75.77,52.58 75.77,52.65 75.88,52.75 v1(76.12,52.75)
  BOTTOM w0.076: UC1.BB34 115.4,67.65 115.32,67.47 114.98,67.35 114.81,67.35 114.66,67.4 114.48,67.4 114.36,67.36 114.12,67.36 114.01,67.4 112.99,67.4 112.84,67.25 110.91,67.25 110.78,67.12 109.66,67.12 109.42,66.89 109.42,66.75 v1(109.63,66.54)
  BOTTOM w0.112: JDIMM1.221 78.26,52.99 78.14,53.11 77.82,53.11 77.63,53.3 75.82,53.3 75.76,53.25 75.76,53.11 v1(76.12,52.75)
DDR_A_DQS7: length 58.3
  IN1 w0.119: v1(106.25,63.64) 106.43,63.45 106.43,63.4 106.43,63.4 106.43,63.08 106,62.65 104.97,61.62 104.97,61.6 104.61,61.24 103.48,61.24 102.35,60.11 102.35,59.36 99.61,56.63 98.45,56.63 96.13,54.3 95.25,54.3 94.46,53.52 94.46,52.9 93.56,51.99 93.39,51.99 93.11,52.27 92.76,52.27 92.22,51.73 92.22,51.38 92.5,51.11 92.5,50.94 89.16,47.59 81.21,47.59 80.63,47.01 79.55,47.01 79.43,47.13 79.43,47.18 79.18,47.43 78.65,47.43 78.4,47.18 78.4,47.13 78.28,47.01 77.02,47.01 76.73,47.3 76.04,47.3 75.75,47.01 74.32,47.01 74.2,47.13 74.2,47.32 74.4,47.52 v1(74.6,47.52)
  BOTTOM w0.076: v1(106.25,63.64) 106.4,63.78 106.4,64.4 106.62,64.62 107.79,64.62 107.92,64.48 112.35,64.48 112.92,65.05 114.04,65.05 114.15,65.01 114.33,65.01 114.45,65.05 114.69,65.05 114.83,65 114.95,65 115.19,65.08 115.25,65.21 115.23,65.32 115.15,65.39 115.01,65.39 UC1.BF35
  BOTTOM w0.112: v1(74.6,47.52) 74.33,47.25 74.33,47.05 74.11,46.83 72.82,46.83 72.44,47.21 72.44,47.69 72.3,47.83 72.03,47.83 71.94,47.74 JDIMM1.242
DDR_A_DQS#0: length 65.9
  IN1 w0.089: 112.81,95.64 112.82,95.64 112.84,95.63 112.89,95.63 113,95.52 113,95.49 113.77,94.72 119.21,94.72 120.58,96.09 120.58,97.8 120.68,97.91 120.68,98.44 v1(120.41,98.71)
  IN1 w0.119: v1(73.84,102.02) 73.98,102.02 74.24,102.28 74.24,102.41 74.48,102.65 86.47,102.65 88.87,100.26 103.56,100.26 106.06,97.76 106.06,97.74 108.16,95.64 112.81,95.64
  BOTTOM w0.076: UC1.C27 120.18,91.44 120.31,91.4 120.4,91.44 120.44,91.54 120.44,91.75 120.4,91.85 120.4,92.09 120.45,92.21 120.45,92.39 120.4,92.5 120.4,93.62 120.55,93.77 120.55,94.1 120.41,94.24 120.41,96.88 120.41,97.09 120.48,97.16 120.48,98.13 120.74,98.4 120.74,98.63 120.67,98.71 v1(120.41,98.71)
  BOTTOM w0.112: v1(73.84,102.02) 74.07,101.78 74.07,101.67 73.96,101.55 72.81,101.55 72.27,102.09 71.87,102.09 71.72,102.24 JDIMM1.32
DDR_A_DQS#1: length 64.2
  IN1 w0.119: v1(76.19,107.23) 76.02,107.23 75.65,107.6 75.65,107.86 75.77,107.98 77.08,107.98 77.52,107.53 77.6,107.53 77.6,107.53 89.39,107.53 92.93,103.99 105.75,103.99 105.87,103.87 105.87,103.21 106.4,102.67 110.31,102.67 110.56,102.92 110.56,103.87 110.68,103.99 115.19,103.99 117.02,102.17 117.02,100.88 117.31,100.58 117.58,100.58 117.7,100.47 117.7,100.22 117.82,100.1 118.03,100.1 v1(118.14,100.22)
  BOTTOM w0.076: UC1.D31 117.66,91.11 117.74,91.19 118.02,91.32 118.09,91.52 118.09,91.78 118.05,91.88 118.05,92.06 118.09,92.18 118.09,92.42 118.05,92.53 118.05,93.55 118.21,93.71 118.21,94.16 117.65,94.71 117.65,98.48 117.75,98.58 117.75,100.33 117.85,100.43 117.93,100.43 v1(118.14,100.22)
  BOTTOM w0.112: JDIMM1.11 78.12,107.49 77.98,107.35 77.73,107.35 77.21,106.82 76.02,106.82 75.91,106.94 75.91,107.09 76.05,107.23 v1(76.19,107.23)
DDR_A_DQS#2: length 52.1
  IN1 w0.089: v1(109.78,91.91) 109.62,92.07 109.62,92.44 109.42,92.64 107.78,92.64 107.59,92.45 106.65,92.45 102.77,96.33 102.18,96.33 102.16,96.35 102.14,96.35
  IN1 w0.119: 102.14,96.35 81.88,96.35 81.18,97.05 77.79,97.05 77.19,97.65 75.66,97.65 75.41,97.4 v1(75.41,96.75)
  BOTTOM w0.076: v1(109.78,91.91) 109.69,91.91 109.55,91.77 109.55,91.5 109.62,91.42 110.78,91.42 111.19,91.01 111.19,90.69 112.14,89.74 112.14,87.85 112.44,87.55 112.7,87.55 112.76,87.55 112.92,87.7 114.04,87.7 114.15,87.66 114.33,87.66 114.45,87.7 114.7,87.7 114.83,87.65 114.97,87.65 115.12,87.71 115.14,87.75 115.14,87.86 115.07,87.93 UC1.J35
  BOTTOM w0.112: v1(75.41,96.75) 75.6,96.94 75.6,97.19 75.99,97.57 77.17,97.57 77.92,96.83 78.2,96.83 78.36,96.99 JDIMM1.53
DDR_A_DQS#3: length 51.5
  IN1 w0.089: v1(108.47,87.99) 108.68,88.21 108.68,88.39 108.44,88.63 106.15,88.63 104.39,90.4 104.37,90.4 102.36,92.41 102.18,92.41 102.16,92.4 102.14,92.4
  IN1 w0.119: 102.14,92.4 87.4,92.4 85.53,90.53 75.58,90.53 75.44,90.4 74.26,90.4 73.99,90.66 73.99,91.1 v1(73.81,91.28)
  BOTTOM w0.076: v1(108.47,87.99) 108.7,87.76 108.7,87.52 108.97,87.26 109.99,87.26 112.38,84.87 112.83,84.87 112.99,85.02 114.01,85.02 114.12,84.98 114.36,84.98 114.48,85.02 114.66,85.02 114.8,84.97 114.96,84.97 115.23,85.07 115.3,85.21 115.3,85.32 115.39,85.41 UC1.P34
  BOTTOM w0.112: v1(73.81,91.28) 74.08,91.02 74.08,90.81 73.99,90.72 72.97,90.72 72.14,91.55 71.87,91.55 71.68,91.74 JDIMM1.74
DDR_A_DQS#4: length 53.5
  IN1 w0.089: v1(107.53,72.84) 107.36,72.67 107.36,72.46 107.16,72.26 103.51,72.26
  IN1 w0.119: v1(75.22,63.65) 75.35,63.52 75.35,63.05 75.59,62.81 77.73,62.81 77.97,63.05 77.97,63.31 78.09,63.43 78.45,63.43 78.57,63.31 78.57,63.05 78.82,62.81 79.36,62.81 79.6,63.05 79.6,63.31 79.72,63.43 80.08,63.43 80.2,63.31 80.2,63.05 80.45,62.81 81.2,62.81 81.45,63.05 81.45,63.16 81.57,63.28 81.92,63.28 82.04,63.16 82.04,63.05 82.29,62.81 82.91,62.81 83.54,63.43 86.07,63.43 91.57,68.93 94.22,68.93 97.04,71.75 103,71.75 103.5,72.26 103.51,72.26
  BOTTOM w0.076: UC1.AP35 115.06,72.66 115.16,72.66 115.25,72.73 115.26,72.84 115.12,73.04 114.95,73.1 114.83,73.1 114.69,73.05 114.45,73.05 114.32,73.09 114.17,73.09 114.06,73.05 114.03,73.05 112.91,73.05 112.73,73.23 108.47,73.23 108.21,73.49 107.51,73.49 107.44,73.41 107.44,72.91 107.51,72.84 v1(107.53,72.84)
  BOTTOM w0.112: JDIMM1.177 77.53,63.99 77.01,64.51 75.57,64.51 75.32,64.26 75.32,63.75 v1(75.22,63.65)
DDR_A_DQS#5: length 53.2
  IN1 w0.089: 102.81,68.58 102.84,68.58 102.89,68.63 102.96,68.63 103.03,68.66 103.9,69.53 104.86,70.48 107.42,70.48 107.6,70.3 107.6,70.08 107.81,69.87 v1(107.93,69.87)
  IN1 w0.119: v1(74.6,58.14) 74.42,57.96 74.42,57.71 74.54,57.59 85.26,57.59 90.9,63.23 93.5,63.23 98.5,68.24 102.47,68.24 102.81,68.58
  BOTTOM w0.076: v1(107.93,69.87) 107.9,69.87 107.66,70.11 107.66,70.22 107.71,70.27 111.87,70.27 112.38,69.76 112.82,69.76 112.98,69.92 114.01,69.92 114.12,69.88 114.36,69.88 114.48,69.92 114.66,69.92 114.75,69.89 115.03,69.89 115.22,69.95 115.32,70.17 115.46,70.31 UC1.AV34
  BOTTOM w0.112: JDIMM1.198 71.98,58.74 72.12,58.6 72.27,58.6 72.76,59.08 74.17,59.08 74.42,58.82 74.42,58.31 v1(74.6,58.14)
DDR_A_DQS#6: length 52.9
  IN1 w0.089: 100.48,64.01 102.07,64.01 102.13,64.07 105.17,67.11 108.94,67.11 109.03,67.02 v1(109.03,66.53)
  IN1 w0.119: 100.48,64.01 99.86,64.01 95.14,59.28 93.74,59.28 86.43,51.98 75.81,51.98 75.54,52.26 75.54,52.58 v1(75.36,52.75)
  BOTTOM w0.076: v1(109.03,66.53) 109.26,66.76 109.26,66.95 109.59,67.29 110.71,67.29 110.84,67.42 112.77,67.42 112.92,67.57 114.04,67.57 114.15,67.53 114.33,67.53 114.45,67.57 114.69,67.57 114.84,67.51 114.95,67.51 115.18,67.6 115.25,67.72 115.23,67.85 115.15,67.92 115.02,67.92 UC1.BB35
  BOTTOM w0.112: JDIMM1.219 78.42,53.49 78.27,53.34 77.91,53.34 77.72,53.53 75.73,53.53 75.54,53.34 75.54,52.94 v1(75.36,52.75)
DDR_A_DQS#7: length 58.1
  IN1 w0.119: v1(106.88,63.64) 106.65,63.4 106.65,63.31 106.65,63.31 106.65,62.99 106.1,62.43 106.09,62.43 105.19,61.53 105.19,61.51 104.7,61.02 103.57,61.02 102.56,60.01 102.56,59.27 99.7,56.41 98.54,56.41 96.22,54.09 95.34,54.09 94.68,53.43 94.68,52.81 93.65,51.78 93.3,51.78 93.02,52.05 92.85,52.05 92.44,51.64 92.44,51.47 92.72,51.2 92.72,50.85 89.25,47.38 81.3,47.38 80.72,46.79 79.46,46.79 79.21,47.04 79.21,47.09 79.09,47.21 78.74,47.21 78.62,47.09 78.62,47.04 78.37,46.79 76.93,46.79 76.64,47.08 76.13,47.08 75.84,46.79 74.23,46.79 73.98,47.04 73.98,47.38 v1(73.84,47.52)
  BOTTOM w0.076: v1(106.88,63.64) 106.56,63.96 106.56,64.33 106.69,64.46 107.72,64.46 107.86,64.32 112.42,64.32 112.99,64.88 114.01,64.88 114.12,64.84 114.36,64.84 114.48,64.88 114.66,64.88 114.8,64.83 114.98,64.83 115.31,64.95 115.39,65.12 UC1.BF34
  BOTTOM w0.112: JDIMM1.240 71.87,48.24 72.04,48.06 72.09,48.05 72.39,48.05 72.66,47.78 72.66,47.3 72.91,47.05 74.02,47.05 74.11,47.14 74.11,47.25 v1(73.84,47.52)
DDR_A_MA0: length 53
  IN1 w0.089: v1(109.11,80.59) 108.66,80.14 104.87,80.14 103,82.01
  IN1 w0.147: 103,82.01 90.61,82.01 84.15,75.55 74.6,75.55 73.92,74.86 71.79,74.86 71.6,74.67 71.6,73.15 71.85,72.89 72.78,72.89 72.93,73.04 v1(72.93,74.02)
  BOTTOM w0.076: v1(109.11,80.59) 109.69,80.59 110.19,80.09 111.58,80.09 112.01,79.65 112.88,79.65 112.91,79.68 112.91,79.68 113.05,79.82 113.82,79.82 UC1.AC37
  BOTTOM w0.14: v1(72.93,74.02) 72.53,74.42 71.86,74.42 71.67,74.24 JDIMM1.144
DDR_A_MA1: length 54.9
  IN1 w0.089: 102.76,82.84 103.15,82.44 103.27,82.44 103.44,82.61 103.57,82.61 103.69,82.49 103.69,82.36 103.53,82.19 103.53,82.07 103.65,81.94 103.78,81.94 103.95,82.11 104.07,82.11 104.2,81.98 104.2,81.86 104.03,81.69 104.03,81.56 104.15,81.44 104.28,81.44 104.45,81.61 104.57,81.61 104.7,81.48 104.7,81.36 104.53,81.19 104.53,81.06 105.1,80.49 106.92,80.49 107.01,80.58 107.01,80.74 106.88,80.87 v1(106.77,80.87)
  IN1 w0.147: 102.76,82.84 90.27,82.84 84.43,76.99 83.44,76.99 83.29,76.85 83.29,76.52 83.14,76.37 82.85,76.37 82.7,76.52 82.7,76.85 82.56,76.99 82.26,76.99 82.11,76.85 82.11,76.52 81.97,76.37 81.67,76.37 81.52,76.52 81.52,76.85 81.38,76.99 81.08,76.99 80.94,76.85 80.94,76.52 80.79,76.37 80.49,76.37 80.35,76.52 80.35,76.85 80.2,76.99 79.9,76.99 79.76,76.85 79.76,76.52 79.61,76.37 79.31,76.37 79.17,76.52 79.17,76.85 79.02,76.99 78.73,76.99 78.58,76.85 78.58,76.52 78.43,76.37 78.14,76.37 77.99,76.52 77.99,76.85 77.84,76.99 76.26,76.99 76.1,76.83 76.1,76.63 76.34,76.39 v1(76.54,76.39)
  BOTTOM w0.076: v1(106.77,80.87) 106.77,80.32 106.99,80.1 109.69,80.1 109.88,79.92 111.51,79.92 111.94,79.49 112.96,79.49 113.13,79.66 113.57,79.66 113.76,79.46 114.03,79.46 114.28,79.6 UC1.AC36
  BOTTOM w0.14: JDIMM1.133 79.15,76.99 78.01,76.99 77.76,77.24 76.29,77.24 76.16,77.11 76.16,76.94 76.24,76.87 76.24,76.69 v1(76.54,76.39)
DDR_A_MA2: length 54.9
  IN1 w0.089: v1(107.94,80.8) 107.46,80.32 104.98,80.32 102.88,82.42
  IN1 w0.147: v1(74.25,76.39) 73.82,76.82 72.48,76.82 72.3,76.64 72.3,76 72.61,75.69 74.16,75.69 74.43,75.96 83.98,75.96 90.44,82.42 102.88,82.42
  BOTTOM w0.076: v1(107.94,80.8) 108.2,81.05 109.18,81.05 109.47,80.76 109.89,80.76 110.36,80.29 111.61,80.29 112.08,79.83 112.82,79.83 112.84,79.85 112.84,79.85 112.99,79.99 114.01,79.99 114.12,79.95 114.36,79.95 114.48,79.99 115.6,79.99 UC1.AC34
  BOTTOM w0.14: v1(74.25,76.39) 73.4,77.24 JDIMM1.132
DDR_A_MA3: length 55.2
  IN1 w0.147: v1(105.6,80.87) 103.23,83.25 90.03,83.25 84.19,77.41 76.09,77.41 75.64,76.96 74.27,76.96 73.99,77.23 72.51,77.23 72.36,77.38 72.36,77.66 72.54,77.83 74.6,77.83 v1(75.03,78.26)
  BOTTOM w0.076: UC1.AC35 114.58,79.41 114.28,79.41 114.07,79.29 113.69,79.29 113.5,79.49 113.2,79.49 113.03,79.32 111.86,79.32 111.42,79.76 106.72,79.76 106.45,80.02
  BOTTOM w0.14: v1(75.03,78.26) 75.61,77.69 78.01,77.69 78.21,77.49 79.15,77.49 JDIMM1.131 ; 106.45,80.02 v1(105.6,80.87)
DDR_A_MA4: length 53.1
  IN1 w0.089: 102.14,85.05 102.48,85.05 104.36,83.18 105.55,83.18 105.63,83.09 105.63,82.83 105.55,82.75 105.47,82.75 105.38,82.66 105.38,82.22 105.53,82.07 105.53,81.79 105.62,81.7 105.82,81.7 105.91,81.79 105.91,82.24 106,82.32 106.25,82.32 106.34,82.24 106.34,81.74 106.43,81.65 106.72,81.65 106.83,81.75 106.83,82.32 v1(106.55,82.6)
  IN1 w0.147: 102.14,85.05 96.68,85.05 95.7,84.08 89.59,84.08 84.21,78.69 73.94,78.69 v1(73.51,78.26)
  BOTTOM w0.076: v1(106.55,82.6) 106.61,82.6 107,82.21 107.77,82.21 108.05,81.93 108.54,81.93 108.78,81.69 109.67,81.69 110.12,81.24 111.06,81.24 111.21,81.09 112.64,81.09 112.98,80.76 114,80.76 114.12,80.8 114.36,80.8 114.48,80.76 114.66,80.76 115.12,80.93 UC1.AA35
  BOTTOM w0.14: JDIMM1.128 71.84,78.24 72.24,77.84 73.09,77.84 v1(73.51,78.26)
DDR_A_MA5: length 56.3
  IN1 w0.147: v1(104.8,84.89) 102.98,86.71 93.89,86.71 93.74,86.56 93.74,85.88 93.59,85.73 88.91,85.73 83.97,80.79 75.29,80.79 75,81.08 72.81,81.08 72.68,80.96 72.68,80.45 72.75,80.38 74.78,80.38 75.03,80.13 v1(75.03,79.95)
  BOTTOM w0.076: UC1.AB35 114.35,80.12 114.13,80.12 114.04,80.15 112.92,80.15 112.84,80.08 112.71,80.01 112.57,80.01 112.44,80.03 111.87,80.37 111.19,80.63 110.13,80.83 109.6,81.08 109.22,81.22 107.7,81.48 106.45,81.79
  BOTTOM w0.14: v1(75.03,79.95) 73.98,78.9 72.13,78.9 71.97,78.74 JDIMM1.126 ; 106.45,81.79 106.09,81.87 105.94,81.98 105.6,82.33 104.91,84.06 104.91,84.21 104.91,84.22 104.91,84.55 104.91,84.77 v1(104.8,84.89)
DDR_A_MA6: length 54.9
  IN1 w0.089: 103.4,83.66 105.6,81.47 106.84,81.47 107,81.63 107,82 107.1,82.1 107.27,82.1 107.35,82.02 107.35,81.78 107.48,81.65 108.1,81.65 108.17,81.72 108.17,81.94 108.07,82.03 107.77,82.03 107.59,82.21 107.59,82.42 v1(107.74,82.57)
  IN1 w0.147: 103.4,83.66 101.64,83.66 101.49,83.81 101.49,84.29 101.34,84.43 101.05,84.43 100.9,84.29 100.9,83.81 100.75,83.66 100.22,83.66 100.07,83.81 100.07,84.24 99.92,84.39 99.63,84.39 99.48,84.24 99.48,83.81 99.34,83.66 98.82,83.66 98.67,83.81 98.67,84.24 98.53,84.39 98.23,84.39 98.08,84.24 98.08,83.81 97.94,83.66 97.44,83.66 97.29,83.81 97.29,84.49 97.15,84.64 96.85,84.64 96.7,84.49 96.7,83.81 96.56,83.66 89.76,83.66 83.92,77.82 83.04,77.82 82.89,77.97 82.89,78.13 82.74,78.28 82.45,78.28 82.3,78.13 82.3,77.97 82.15,77.82 81.86,77.82 81.71,77.97 81.71,78.13 81.56,78.28 81.27,78.28 81.12,78.13 81.12,77.97 80.97,77.82 79.88,77.82 79.73,77.97 79.73,78.13 79.59,78.28 79.29,78.28 79.14,78.13 79.14,77.97 79,77.82 78.7,77.82 78.56,77.97 78.56,78.13 78.41,78.28 78.11,78.28 77.97,78.13 77.97,77.97 77.82,77.82 76.68,77.82 76.53,77.97 76.53,78.24 v1(76.56,78.26)
  BOTTOM w0.076: v1(107.74,82.57) 108.22,82.09 108.35,82.09 108.62,82.09 108.83,81.88 109.71,81.88 110.18,81.4 111.13,81.4 111.27,81.26 112.71,81.26 113.05,80.92 113.81,80.92 UC1.AA37
  BOTTOM w0.14: v1(76.56,78.26) 76.56,78.61 76.78,78.84 77.67,78.84 78.02,78.49 79.15,78.49 JDIMM1.127
DDR_A_MA7: length 54.2
  IN1 w0.089: 102.14,85.47 102.58,85.47 104.7,83.35 107.54,83.35 v1(108.35,82.55)
  IN1 w0.147: v1(72.11,79.95) 72.11,81.38 71.96,81.53 71.43,81.53 71.28,81.38 71.28,78.88 71.43,78.74 73.39,78.74 73.77,79.11 84.04,79.11 89.42,84.49 95.53,84.49 96.51,85.47 102.14,85.47
  BOTTOM w0.076: UC1.AA36 114.53,81.01 114.17,81.19 114.11,81.25 114.03,81.29 113.77,81.29 113.57,81.09 113.12,81.09 112.78,81.42 111.34,81.42 111.2,81.57 110.25,81.57 109.78,82.04 108.9,82.04 108.39,82.55 v1(108.35,82.55)
  BOTTOM w0.14: JDIMM1.122 71.9,79.74 v1(72.11,79.95)
DDR_A_MA8: length 52.4
  IN1 w0.147: v1(105.71,83.9) 105.17,83.9 102.77,86.3 95.48,86.3 95.33,86.15 95.33,85.47 95.19,85.32 94.89,85.32 94.74,85.47 94.74,86.15 94.6,86.3 94.3,86.3 94.16,86.15 94.16,85.47 94.01,85.32 89.08,85.32 83.76,80.01 83.37,80.01 83.22,80.15 83.22,80.32 83.16,80.38 82.75,80.38 82.6,80.23 82.6,80.08 82.45,79.93 82.16,79.93 82.01,80.08 82.01,80.23 81.86,80.38 81.57,80.38 81.42,80.23 81.42,80.08 81.28,79.93 80.98,79.93 80.83,80.08 80.83,80.23 80.69,80.38 79.77,80.38 79.63,80.23 79.63,80.08 79.48,79.93 79.18,79.93 79.04,80.08 79.04,80.23 78.89,80.38 78.59,80.38 78.45,80.23 78.45,80.08 78.3,79.93 78.01,79.93 77.86,80.08 77.86,80.23 77.71,80.38 76.99,80.38 v1(76.56,79.95)
  BOTTOM w0.076: UC1.AB34 115,80.63 114.78,80.63 114.69,80.6 114.45,80.6 114.33,80.64 114.15,80.64 114.03,80.59 112.91,80.59 112.83,80.67 112.73,80.73 112.62,80.75 111.52,80.79 109.96,81.1 109.41,81.35 107.01,81.97 106.74,82.1 106.7,82.17 106.53,82.21 106.45,82.21
  BOTTOM w0.14: 106.45,82.21 106.43,82.21 106.3,82.24 106.06,82.48 106.06,82.8 v1(105.71,83.9) ; JDIMM1.125 79.15,78.99 78.1,78.99 77.85,79.24 76.55,79.24 76.36,79.43 76.36,79.75 v1(76.56,79.95)
DDR_A_MA9: length 53.5
  IN1 w0.089: v1(106.96,83.95) 107.1,84.1 107.1,84.42 106.95,84.58 105.62,84.58 103.08,87.13 102.78,87.13
  IN1 w0.147: v1(75.03,81.64) 75.47,81.21 77.72,81.21 77.87,81.35 77.87,81.51 78.02,81.66 78.31,81.66 78.46,81.51 78.46,81.35 78.61,81.21 83.79,81.21 88.73,86.15 93.18,86.15 93.33,86.29 93.33,86.93 93.52,87.13 102.78,87.13
  BOTTOM w0.076: v1(106.96,83.95) 107.76,83.15 108.09,83.15 108.17,83.22 108.17,83.76 108.25,83.83 108.4,83.83 108.48,83.76 108.48,83.22 108.55,83.15 108.7,83.15 108.78,83.22 108.78,83.76 108.86,83.83 109.01,83.83 109.09,83.76 109.09,83.22 109.16,83.15 109.31,83.15 109.39,83.22 109.39,83.41 109.47,83.48 110.01,83.48 111.51,81.98 112.93,81.98 113.12,82.17 113.57,82.17 113.76,81.98 114.03,81.98 114.51,82.24 114.51,82.24 UC1.W36
  BOTTOM w0.14: JDIMM1.121 79.15,79.99 78.15,79.99 77.59,80.55 76.07,80.55 75.03,81.58 v1(75.03,81.64)
DDR_A_MA10: length 52.1
  IN1 w0.089: 103.89,78.24 103.96,78.31 110.72,78.31 111.38,78.96 112.59,78.96 113.24,79.61 114.35,79.61 116.22,81.48 116.22,81.83 116.49,82.1 116.94,82.1 v1(117.3,81.74)
  IN1 w0.147: 103.89,78.24 91.33,78.24 85.01,71.92 76.72,71.92 76.39,71.59 74.15,71.59 v1(73.44,72.3)
  BOTTOM w0.102: UC1.Y31 117.32,81.71 v1(117.3,81.74)
  BOTTOM w0.14: v1(73.44,72.3) 72.89,71.74 70.95,71.74 JDIMM1.146
DDR_A_MA11: length 50.7
  IN1 w0.089: 102.68,85.88 105.03,83.53 107.78,83.53 108.39,82.92 109.48,82.92 109.57,82.83 v1(109.57,82.45)
  IN1 w0.147: 102.68,85.88 96.34,85.88 95.36,84.91 89.25,84.91 83.86,79.52 73.54,79.52 73.42,79.65 73.42,79.86 v1(73.51,79.95)
  BOTTOM w0.076: v1(109.57,82.45) 109.57,82.47 109.78,82.68 110.56,82.68 111.42,81.81 113,81.81 113.19,82 113.5,82 113.69,81.81 114.07,81.81 114.3,81.94 115.24,81.94 115.86,82.24 UC1.W34
  BOTTOM w0.14: JDIMM1.120 71.71,80.24 71.92,80.45 73.01,80.45 v1(73.51,79.95)
DDR_A_MA12: length 53.6
  IN1 w0.089: v1(110.69,81.94) 110.94,82.19 110.94,82.38 110.85,82.47 110.43,82.47 110.33,82.57 110.33,82.71 110.51,82.9 110.51,83 110.28,83.24 110.22,83.24 109.89,82.92 109.77,82.92 109.44,83.24 109.44,83.47 109.36,83.56 109.06,83.56 108.97,83.47 108.97,83.24 108.89,83.15 108.43,83.15 108.26,83.32 108.26,83.45 108.34,83.53 108.34,83.65 108.13,83.86 108.01,83.86 107.86,83.72 107.74,83.72 107.53,83.92 107.53,84.05 107.77,84.29 107.77,84.42 107.56,84.62 107.44,84.62 107.4,84.58 107.27,84.58 107.1,84.76 105.7,84.76 102.92,87.54 102.65,87.54
  IN1 w0.147: v1(76.56,81.64) 76.56,81.91 76.71,82.07 78.85,82.07 78.99,81.92 78.99,81.77 79.14,81.62 79.43,81.62 79.58,81.77 79.58,81.92 79.73,82.07 81.21,82.07 81.35,81.92 81.35,81.77 81.5,81.62 81.8,81.62 81.94,81.77 81.94,81.92 82.09,82.07 82.39,82.07 82.53,81.92 82.53,81.77 82.68,81.62 82.97,81.62 83.12,81.77 83.12,81.92 83.27,82.07 84.07,82.07 88.56,86.56 92.37,86.56 93.35,87.54 102.65,87.54
  BOTTOM w0.076: v1(110.69,81.94) 111.06,81.94 111.39,81.61 112.83,81.61 113.19,81.25 113.5,81.25 113.7,81.46 114.08,81.46 114.21,81.38 114.23,81.37 114.27,81.34 115.22,81.34 UC1.AA34
  BOTTOM w0.14: v1(76.56,81.64) 76.4,81.64 76.07,81.31 76.07,81.12 76.23,80.96 77.85,80.96 78.32,80.49 JDIMM1.119
