# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CRX_DTX_P16: length 183.5
  IN1 w0.089: 136.91,65.16 136.89,65.16 136.88,65.15 136.32,65.15 135.56,65.91 134.77,65.91 134.66,65.8 133.71,65.8 133.51,65.6 133.51,65.32 v1(133.42,65.23)
  IN1 w0.119: 136.91,65.16 138.17,65.16 139.72,66.72 144.5,66.72 149.98,61.23 149.98,55.85 149.32,55.19 149.32,52.45 147.35,50.48 147.35,34.04 145.08,31.77 140.18,31.77 136.87,31.77 133.55,28.44 131.35,28.44 128.3,25.4 101.06,25.4 100.11,24.45 65.2,24.45 56.43,33.22 55.14,33.22 54.67,33.69 46.74,33.69 46.17,34.26 40.76,34.26 40.3,33.79 29.88,33.79 29.68,33.98 28.68,33.98 27.59,35.08 27.59,36.29 27.86,36.56 v1(28.84,36.56)
  BOTTOM w0.102: UC1.BE6 133.2,65.44 v1(133.42,65.23)
  BOTTOM w0.112: v1(28.84,36.56) 28.88,36.51 29.41,36.51 29.65,36.27 29.65,35.22 29.38,34.95 JSSD1.41
PCIE_CTX_C_DRX_N9: length 3
  TOP w0.112: CL14.2 28.48,82.06 28.25,82.06 v4(27.84,82.48) 27.54,82.78 26.87,82.78 26.78,82.86 UL1.14
PCIE_CTX_C_DRX_N10: length 16
  BOTTOM w0.112: JWLAN1.37 78.32,129.65 78.25,129.58 77.33,129.58 76.87,129.11 76.87,128.33 75.85,127.31 75.36,127.31 74.08,126.03 74.08,122.36 72.55,120.84 72.55,119.35 72.23,119.03 CW6.2
PCIE_CTX_C_DRX_N13: length 2.4
  BOTTOM w0.112: JSSD1.11 36.87,34.78 36.74,34.92 36.74,35.11 36.28,35.56 36.28,35.7 CS7.2
PCIE_CTX_C_DRX_N14: length 2.2
  BOTTOM w0.112: JSSD1.23 33.87,34.86 33.75,34.98 33.75,35.71 CS9.2
PCIE_CTX_C_DRX_N15: length 2.2
  BOTTOM w0.112: CS11.2 30.7,35.71 30.7,35.05 30.87,34.88 JSSD1.35
PCIE_CTX_C_DRX_N16: length 2.3
  BOTTOM w0.112: CS13.2 27.74,35.8 27.74,35.64 27.79,35.59 27.79,35.07 27.67,34.95 27.67,34.8 27.87,34.6 JSSD1.47
PCIE_CTX_C_DRX_P9: length 3
  TOP w0.112: CL13.2 28.47,81.84 28.16,81.84 27.88,82.12 27.86,82.12 27.43,82.55 26.8,82.55 26.71,82.46 UL1.13
PCIE_CTX_C_DRX_P10: length 16
  BOTTOM w0.112: JWLAN1.35 78.45,129.15 78.24,129.36 77.42,129.36 77.09,129.02 77.09,128.24 75.94,127.09 75.45,127.09 74.3,125.94 74.3,122.27 72.77,120.74 72.77,119.25 72.45,118.94 72.45,118.32 72.69,118.09 72.77,118.09 CW5.2
PCIE_CTX_C_DRX_P13: length 2.4
  BOTTOM w0.112: CS8.2 36.06,35.7 36.06,35.47 36.51,35.02 36.51,34.82 36.38,34.69 JSSD1.13
PCIE_CTX_C_DRX_P14: length 2.2
  BOTTOM w0.112: JSSD1.25 33.38,34.83 33.53,34.98 33.53,35.69 CS10.2
PCIE_CTX_C_DRX_P15: length 2.2
  BOTTOM w0.112: JSSD1.37 30.38,34.7 30.48,34.81 30.48,35.69 CS12.2
PCIE_CTX_C_DRX_P16: length 2.3
  BOTTOM w0.112: JSSD1.49 27.38,34.77 27.45,34.84 27.45,35.05 27.57,35.17 27.57,35.5 27.09,35.97 CS14.2
PCIE_CTX_DRX_N9: length 183.5
  TOP w0.112: v1(30.49,82.21) 30.3,82.03 30.09,82.03 CL14.1
  IN1 w0.119: v1(30.49,82.21) 29.63,82.21 28.64,81.23 28.64,77.34 25.28,73.97 25.28,56.81 35.67,46.42 40.43,46.42 44.29,42.56 47.92,42.56 49.35,41.13 60.09,41.13 62.06,39.16 63.08,39.16 65.54,36.69 67.39,36.69 68.62,35.46 69.86,35.46 72.23,33.09 76.19,33.09 77.08,32.2 79.91,32.2 80.36,31.75 83.67,31.75 84.35,32.44 94.95,32.44 95.54,33.02 101.89,33.02 102.47,32.44 103.34,32.44 103.92,33.02 118.09,33.02 118.58,33.51 121.04,33.51 122.8,35.27 126.82,35.27 128.18,36.63 130.81,36.63 132.27,38.1 132.27,38.63 132.27,42.71 134.49,44.93 136.11,46.55 136.11,47.31 137.12,48.32 137.12,51.12 138.33,52.33 138.33,52.85 139.11,53.63 139.49,53.63 140.22,54.36 140.7,54.36 142.66,56.32 142.66,57 141.23,58.43 v1(141.23,60.42)
  BOTTOM w0.076: UC1.BR2 136.21,59.81 136.51,59.5 141.01,59.5 141.23,59.72 v1(141.23,60.42)
PCIE_CTX_DRX_N10: length 115.3
  IN1 w0.089: v1(138.31,60.6) 138.31,61.21 137.82,61.7 133.44,61.7 133,62.14 131.95,62.14 131.66,62.43 131.66,62.44 131.67,62.45
  IN1 w0.119: 131.67,62.45 131.67,94.48 131.01,95.15 129.38,95.15 117.55,106.98 107.62,106.98 105.41,109.18 93.6,109.18 89.48,113.31 81.02,113.31 79.37,114.96 75.95,114.96 74.06,116.85 73.22,116.85 72.87,116.5 v1(72.87,115.6)
  BOTTOM w0.076: UC1.BR4 134.6,59.88 135.13,59.63 135.32,59.63 135.44,59.67 135.56,59.78 135.56,59.97 135.68,60.1 135.84,60.15 135.99,60.15 136.08,60.12 136.36,60.12 136.46,60.15 136.7,60.15 136.85,60.01 137.4,60.01 137.58,59.83 138.1,59.83 138.31,60.04 v1(138.31,60.6)
  BOTTOM w0.112: CW6.1 72.53,116.53 72.53,116.26 72.87,115.91 v1(72.87,115.6)
PCIE_CTX_DRX_N13: length 152.2
  IN1 w0.119: v1(37.23,39.17) 37.23,39.4 36.99,39.63 36.94,39.63 36.86,39.71 36.86,39.94 36.98,40.06 46.88,40.06 48.72,38.22 54.14,38.22 54.68,38.76 58.75,38.76 62.75,34.76 66.59,34.76 67.82,33.53 68.33,33.53 71.58,30.28 75.54,30.28 76.83,28.99 86.72,28.99 87.17,29.44 89.29,29.44 89.52,29.67 96.59,29.67 97.75,30.83 100.71,30.83 101.13,30.41 102.88,30.41 103.39,29.9 106.16,29.9 106.68,30.41 115.77,30.41 116.42,31.06 122.38,31.06 123.01,31.69 127.8,31.69 128.52,32.41 128.52,33.04 129.07,33.59 131.41,33.59 132.67,34.85 133.59,34.85 135.25,36.51 138.35,36.51 140.38,38.54 140.38,42.71 139.54,43.56 139.54,50.47 142.66,53.59 142.66,54.89 144.73,56.96 144.73,58.77 143.61,59.88 142.98,59.88 140.99,61.87 138.54,61.87 138.42,61.99 138.42,62.19 v1(138.54,62.31)
  BOTTOM w0.076: UC1.BM4 135.52,61.48 136.19,61.48 136.41,61.7 138.04,61.7 138.36,62.01 138.36,62.13 v1(138.54,62.31)
  BOTTOM w0.112: CS7.1 36.28,37.28 36.28,37.55 37.23,38.5 v1(37.23,39.17)
PCIE_CTX_DRX_N14: length 160.5
  IN1 w0.119: v1(139.71,62.29) 139.71,62.87 139.96,63.12 141.8,63.12 142.34,63.66 143.92,63.66 147.41,60.17 147.41,56.91 144.58,54.09 144.58,52.79 141.9,50.1 141.9,43.95 142.31,43.54 142.31,37.74 139.03,34.46 135.93,34.46 134.39,32.92 133.47,32.92 132.21,31.66 130.93,31.66 128.95,29.68 127.66,29.68 126.65,28.67 122.75,28.67 122.44,28.99 120.4,28.99 120.11,28.7 118.33,28.7 117.6,27.97 102.59,27.97 102.19,28.37 101.84,28.37 101.44,27.97 99.93,27.97 98.98,27.02 70.75,27.02 69.91,27.86 69.91,29.23 69.5,29.64 66.37,29.64 63.18,32.84 61.87,32.84 60.42,34.29 59.03,34.29 56.48,36.83 55.48,36.83 54.94,36.29 47.8,36.29 45.96,38.13 40.56,38.13 39.56,37.14 35.2,37.14 34.75,37.59 v1(33.94,37.59)
  BOTTOM w0.076: v1(139.71,62.29) 139.91,62.49 139.91,62.66 139.82,62.76 137.9,62.76 137.17,62.02 136.52,62.02 UC1.BL2
  BOTTOM w0.112: CS9.1 33.74,37.29 33.74,37.39 v1(33.94,37.59)
PCIE_CTX_DRX_N15: length 162.4
  IN1 w0.119: v1(31.15,38.67) 31.23,38.59 31.23,38.32 31.14,38.24 30.9,38.24 30.78,38.12 30.78,37.91 30.91,37.79 31.72,37.79 32.2,38.27 32.2,39.24 32.61,39.65 34.95,39.65 35.84,38.76 39.06,38.76 39.93,39.63 46.7,39.63 48.54,37.79 54.31,37.79 54.86,38.33 58.5,38.33 62.49,34.34 66.41,34.34 67.64,33.11 68.16,33.11 71.69,29.58 75.34,29.58 76.35,28.57 89.1,28.57 89.61,29.08 93.71,29.08 93.87,29.24 97.36,29.24 97.59,29.47 100.81,29.47 101.22,29.88 102.81,29.88 103.22,29.47 115.43,29.47 116.12,30.16 117.4,30.16 117.86,30.62 122.55,30.62 123.19,31.27 128.41,31.27 130.3,33.16 131.58,33.16 132.85,34.43 133.76,34.43 135.3,35.96 138.4,35.96 140.8,38.36 140.8,42.92 139.96,43.76 139.96,50.3 143.08,53.42 143.08,54.71 145.9,57.54 145.9,58.87 144.47,60.3 143.16,60.3 141.83,61.63 141.83,61.94 141.63,62.13 141.63,62.14 v1(141.46,62.31)
  BOTTOM w0.076: UC1.BL4 134.85,62.07 135.4,62.07 135.55,62.22 135.55,62.42 135.67,62.53 135.8,62.59 135.99,62.59 136.08,62.56 136.36,62.56 136.46,62.59 136.86,62.59 137.39,63.12 141.17,63.12 141.46,62.82 v1(141.46,62.31)
  BOTTOM w0.112: v1(31.15,38.67) 31.02,38.54 31.02,38.18 30.51,37.67 30.51,37.47 CS11.1
PCIE_CTX_DRX_N16: length 167.8
  IN1 w0.119: v1(142.66,62.29) 142.78,62.41 142.78,62.77 143.02,63.02 143.65,63.02 146.76,59.9 146.76,57.18 143.94,54.36 143.94,53.06 140.84,49.96 140.84,44.09 141.66,43.27 141.66,38.01 138.76,35.1 135.66,35.1 134.12,33.56 133.2,33.56 131.94,32.3 130.66,32.3 128.68,30.32 123.75,30.32 123.19,29.76 118.38,29.76 117.92,29.3 116.48,29.3 115.79,28.61 102.86,28.61 102.45,29.02 101.58,29.02 101.17,28.61 99.66,28.61 98.71,27.66 94.35,27.66 93.79,28.22 89.97,28.22 89.4,27.66 71.02,27.66 70.55,28.12 70.55,29.5 69.77,30.28 66.64,30.28 63.44,33.48 62.14,33.48 58.14,37.47 55.21,37.47 54.67,36.93 48.07,36.93 46.23,38.77 40.29,38.77 39.3,37.78 35.6,37.78 34.59,38.79 33.2,38.79 33.06,38.65 33.06,37.91 32.07,36.92 30.42,36.92 29.93,37.42 29.07,37.42 v1(28.99,37.34)
  BOTTOM w0.076: UC1.BJ4 134.81,63.53 135.16,63.38 135.43,63.38 135.6,63.3 135.69,63.24 135.86,63.21 136.02,63.21 136.06,63.21 136.07,63.22 136.12,63.24 136.14,63.24 136.29,63.24 136.42,63.2 136.77,63.2 137.02,63.46 137.62,63.46 137.63,63.44 141.55,63.44 141.83,63.16 142.51,63.16 142.51,63.16 142.52,63.16
  BOTTOM w0.112: CS13.1 27.82,37.11 27.82,37.42 27.93,37.53 28.8,37.53 v1(28.99,37.34) ; v1(142.66,62.29) 142.86,62.49 142.86,62.84 142.84,62.86 142.84,63.04 142.72,63.16 142.52,63.16
PCIE_CTX_DRX_P9: length 183.5
  TOP w0.112: v1(30.49,81.63) 30.31,81.81 30.03,81.81 CL13.1
  IN1 w0.119: v1(30.49,81.63) 30.49,81.33 30.37,81.21 30.19,81.21 30.07,81.33 30.07,81.87 29.95,81.99 29.72,81.99 28.86,81.14 28.86,77.25 25.5,73.88 25.5,56.9 35.76,46.64 40.52,46.64 44.38,42.78 48.01,42.78 49.44,41.35 60.18,41.35 62.16,39.37 63.17,39.37 65.64,36.91 67.48,36.91 68.71,35.68 69.95,35.68 72.32,33.3 76.28,33.3 77.17,32.42 80,32.42 80.45,31.97 83.58,31.97 84.26,32.65 94.86,32.65 95.44,33.24 101.98,33.24 102.56,32.66 103.25,32.66 103.83,33.24 118,33.24 118.48,33.73 120.94,33.73 122.71,35.49 126.73,35.49 128.09,36.85 130.72,36.85 132.05,38.19 132.05,38.54 132.05,42.8 135.89,46.64 135.89,47.4 136.9,48.41 136.9,51.22 138.11,52.42 138.11,52.94 139.02,53.85 139.4,53.85 140.13,54.58 140.61,54.58 142.44,56.41 142.44,56.91 141.01,58.34 141.01,60.05 140.81,60.25 140.81,60.25 v1(140.64,60.42)
  BOTTOM w0.076: v1(140.64,60.42) 140.47,60.42 140.32,60.27 140.32,60.12 140.43,60 140.99,60 141.06,59.93 141.06,59.79 140.94,59.67 136.63,59.67 136.55,59.75 UC1.BR1
PCIE_CTX_DRX_P10: length 115.3
  IN1 w0.089: 131.47,62.33 131.51,62.29 131.53,62.29 131.86,61.96 132.93,61.96 133.36,61.53 137.74,61.53 138.13,61.14 138.13,61 v1(137.72,60.59)
  IN1 w0.119: 131.47,62.33 131.45,62.35 131.45,94.39 130.92,94.93 129.29,94.93 117.46,106.76 107.53,106.76 105.32,108.97 93.51,108.97 89.39,113.09 80.93,113.09 79.28,114.74 75.86,114.74 73.97,116.63 73.31,116.63 73.09,116.41 73.09,116.13 73.19,116.04 73.35,116.04 73.46,115.93 v1(73.46,115.6)
  BOTTOM w0.076: v1(137.72,60.59) 137.7,60.57 137.7,60.36 137.78,60.28 138.09,60.28 138.14,60.23 138.14,60.11 138.03,60 137.64,60 137.47,60.17 136.92,60.17 136.77,60.32 136.43,60.32 136.33,60.28 136.11,60.28 136.02,60.32 135.81,60.32 135.59,60.25 135.52,60.17 134.95,60.17 134.87,60.1 134.87,59.99 134.97,59.89 UC1.BR3
  BOTTOM w0.112: v1(73.46,115.6) 73.1,115.96 73.1,116.01 72.75,116.36 72.75,116.45 CW5.1
PCIE_CTX_DRX_P13: length 152.2
  IN1 w0.119: v1(36.64,39.17) 36.64,40.03 36.89,40.27 46.97,40.27 48.81,38.43 54.05,38.43 54.59,38.98 58.84,38.98 62.84,34.98 66.68,34.98 67.91,33.75 68.42,33.75 71.67,30.5 75.63,30.5 76.93,29.21 86.63,29.21 87.07,29.65 89.2,29.65 89.43,29.88 96.5,29.88 97.66,31.05 100.8,31.05 101.22,30.63 102.97,30.63 103.48,30.11 106.07,30.11 106.59,30.63 115.68,30.63 116.33,31.28 122.29,31.28 122.92,31.91 127.71,31.91 128.3,32.5 128.3,33.13 128.98,33.81 131.32,33.81 132.58,35.07 133.5,35.07 135.16,36.73 138.26,36.73 140.16,38.63 140.16,42.62 139.32,43.46 139.32,50.56 142.44,53.68 142.44,54.98 144.51,57.05 144.51,58.67 143.52,59.66 142.89,59.66 140.9,61.65 138.45,61.65 138.2,61.9 138.2,62.07 v1(137.96,62.31)
  BOTTOM w0.076: v1(137.96,62.31) 138.06,62.31 138.19,62.19 138.19,62.08 137.97,61.86 137.75,61.86 137.7,61.91 137.7,61.98 137.63,62.06 137.43,62.06 137.36,61.98 137.36,61.96 137.26,61.86 136.34,61.86 136.13,61.65 135.95,61.65 135.87,61.72 135.87,62.01 135.81,62.08 135.64,62.08 135.51,61.96 135.51,61.82 UC1.BM3
  BOTTOM w0.112: v1(36.64,39.17) 37.01,38.81 37.01,38.59 36.06,37.65 36.06,37.28 CS8.1
PCIE_CTX_DRX_P14: length 160.5
  IN1 w0.119: v1(140.3,62.29) 140.13,62.46 140.13,62.46 139.93,62.66 139.93,62.78 140.05,62.9 141.89,62.9 142.43,63.44 143.83,63.44 147.19,60.08 147.19,57 144.36,54.18 144.36,52.88 141.68,50.19 141.68,43.86 142.09,43.45 142.09,37.83 138.94,34.68 135.84,34.68 134.3,33.14 133.38,33.14 132.12,31.88 130.84,31.88 128.86,29.9 127.57,29.9 126.56,28.89 122.84,28.89 122.53,29.2 120.31,29.2 120.02,28.92 118.24,28.92 117.51,28.19 102.68,28.19 102.28,28.59 101.75,28.59 101.35,28.19 99.84,28.19 98.89,27.24 70.84,27.24 70.13,27.95 70.13,29.32 69.59,29.86 66.46,29.86 63.27,33.05 61.96,33.05 60.51,34.5 59.12,34.5 56.57,37.05 55.39,37.05 54.85,36.51 47.89,36.51 46.05,38.35 40.47,38.35 39.47,37.35 35.29,37.35 34.84,37.81 34.31,37.81 34.11,38 33.77,38 33.36,37.59 v1(33.36,37.57)
  BOTTOM w0.076: v1(140.3,62.29) 140.08,62.51 140.08,62.73 139.89,62.92 137.83,62.92 137.78,62.87 137.67,62.87 137.58,62.95 137.45,62.95 137.36,62.86 137.36,62.75 137.45,62.65 137.45,62.54 137.31,62.4 137.21,62.4 137.17,62.44 137.06,62.44 136.94,62.31 136.94,62.27 136.86,62.19 136.62,62.19 136.55,62.27 UC1.BL1
  BOTTOM w0.112: v1(33.36,37.57) 33.52,37.41 33.52,37.28 CS10.1
PCIE_CTX_DRX_P15: length 162.4
  IN1 w0.119: v1(142.05,62.31) 142.05,61.72 143.25,60.52 144.56,60.52 146.12,58.96 146.12,57.45 143.3,54.62 143.3,53.32 140.18,50.21 140.18,43.85 141.02,43.01 141.02,38.27 138.49,35.75 135.39,35.75 133.85,34.21 132.94,34.21 131.67,32.94 130.4,32.94 128.5,31.05 123.28,31.05 122.64,30.41 117.95,30.41 117.49,29.95 116.21,29.95 115.52,29.25 103.13,29.25 102.72,29.66 101.31,29.66 100.9,29.25 97.68,29.25 97.45,29.02 93.96,29.02 93.8,28.87 89.7,28.87 89.19,28.35 76.26,28.35 75.25,29.36 71.59,29.36 68.07,32.89 67.55,32.89 66.32,34.12 62.4,34.12 58.41,38.12 54.95,38.12 54.41,37.57 48.45,37.57 46.61,39.41 40.02,39.41 39.15,38.54 35.75,38.54 34.86,39.43 32.7,39.43 32.42,39.15 32.42,38.18 31.81,37.57 30.82,37.57 30.56,37.82 v1(30.56,38.67)
  BOTTOM w0.076: UC1.BL3 135.21,62.37 135.21,62.49 135.31,62.59 135.49,62.59 135.57,62.67 135.76,62.76 136.02,62.76 136.11,62.72 136.33,62.72 136.43,62.76 136.79,62.76 137.32,63.28 141.24,63.28 141.63,62.89 141.63,62.75 141.71,62.67 142.01,62.67 142.12,62.56 142.12,62.38 v1(142.05,62.31)
  BOTTOM w0.112: CS12.1 30.29,37.09 30.29,37.76 30.8,38.28 30.8,38.43 v1(30.56,38.67)
PCIE_CTX_DRX_P16: length 167.8
  IN1 w0.119: v1(143.24,62.29) 143.2,62.29 143.07,62.42 143.07,62.46 142.99,62.54 142.99,62.68 143.11,62.8 143.56,62.8 146.55,59.81 146.55,57.27 143.72,54.45 143.72,53.15 140.62,50.05 140.62,44 141.44,43.18 141.44,38.1 138.67,35.32 135.57,35.32 134.03,33.78 133.11,33.78 131.85,32.52 130.57,32.52 128.59,30.54 123.66,30.54 123.1,29.98 118.29,29.98 117.83,29.52 116.39,29.52 115.69,28.83 102.95,28.83 102.54,29.23 101.49,29.23 101.08,28.83 99.57,28.83 98.62,27.88 94.44,27.88 93.88,28.44 89.88,28.44 89.31,27.88 71.11,27.88 70.77,28.21 70.77,29.59 69.86,30.5 66.73,30.5 63.53,33.7 62.23,33.7 58.23,37.69 55.12,37.69 54.58,37.15 48.16,37.15 46.32,38.99 40.2,38.99 39.21,38 35.69,38 34.68,39.01 33.11,39.01 32.84,38.74 32.84,38 31.98,37.14 30.51,37.14 30.02,37.64 29.28,37.64 29.16,37.76 29.16,37.76 v1(28.99,37.93)
  BOTTOM w0.076: UC1.BJ3 135.19,63.7 135.19,63.86 135.27,63.94 135.47,63.94 135.59,63.82 135.59,63.5 135.6,63.48 135.68,63.45 135.75,63.4 135.88,63.38 136.02,63.38 136.02,63.38 136.06,63.39 136.11,63.41 136.31,63.41 136.45,63.37 136.7,63.37 136.95,63.62 137.69,63.62 137.7,63.61 141.61,63.61 141.9,63.33 142.45,63.33 142.5,63.38 142.52,63.38
  BOTTOM w0.112: v1(143.24,62.29) 143.06,62.47 143.06,63.13 142.81,63.38 142.52,63.38 ; v1(28.99,37.93) 28.82,37.75 27.84,37.75 27.6,37.51 27.6,37.38 27.17,36.95 CS14.1
PCIE_RCOMPN: length 3.8
  TOP w0.254: RC126.2 132.2,51.11 132.04,51.28 132.04,51.59 132.22,51.77 132.5,51.77 133.07,52.35 133.07,52.46 133.42,52.81 v1(133.42,53.22)
  BOTTOM w0.254: UC1.CE6 v1(133.42,53.22)
PCIE_RCOMPP: length 3.7
  TOP w0.254: RC126.1 133.73,51.11 134.77,52.15 v2(134.77,52.71) 134.28,53.2 v1(134.06,53.2)
  BOTTOM w0.254: UC1.CE5 v1(134.06,53.2)
PCIE_WAKE#: length 321.4
  TOP w0.112: UL1.21 24,84.73 24.23,84.97 24.23,85.32 v1(24.23,85.32) ; v1(99.14,37.49) 99.18,37.49 100.12,38.43 100.12,43.95 99.63,44.44 99.63,44.63 99.92,44.92 99.92,48.36 101.94,50.39 v2(101.94,51.94) 101.94,53.14 102.45,53.65 104.3,53.65 104.62,53.97 RC102.1 ; v1(47.96,70.55) 47.61,70.55 46.8,71.37 46.8,72.32 46.35,72.76 41.85,72.76 40.79,71.7 38.65,71.7 37.95,70.99 v1(37.95,70.54) 38.55,69.94 UE1.4 ; RW10.1 v1(74.2,137.75)
  IN1 w0.119: v1(26.13,27.62) 26.13,26.68 24.95,25.5 20.4,25.5 18.77,27.13 18.77,30.97 19.85,32.05 19.85,32.06 19.94,32.14 19.94,41.08 20.17,41.31 20.17,41.33 21.05,42.22 21.05,43.51 22.29,44.75 22.29,51.04 22.62,51.37 22.62,57.18 24.36,58.92 24.36,63.42 24.86,63.93 24.86,75.75 24.31,76.3 24.31,78.68 26.28,80.66 v1(26.28,84.36) ; v1(74.2,137.75) 74.18,137.73 74.08,137.73 73.02,136.66 72.47,136.66 71.14,137.99 67.1,137.99 62.39,133.28 62.39,130.71 58.92,127.23 58.92,126.39 56.98,124.45 56.98,123.25 50.5,116.77 v1(50.45,116.77)
  IN3 w0.135: v1(99.14,37.49) 98.83,37.81 92.62,37.81 90.44,35.62 90.44,32.78 88.61,30.96 87.58,30.96 86.53,29.9 69.93,29.9 69.53,30.3 65.56,30.3 64.05,31.81 60.29,31.81 58.99,33.12 58.37,33.12 56.88,34.61 55.48,34.61 54.79,35.3 50.36,35.3 44.8,40.85 44.8,46.99 43.91,47.87 43.91,52.32 46.9,55.3 46.9,61.53 47.47,62.1 47.47,70.06 v1(47.96,70.55) ; v1(50.45,116.77) 43.08,116.77 35.21,108.9 30.77,108.9 23.39,101.52 23.39,98.32 21.94,96.86 20.77,96.86 19.59,95.69 19.59,88.23 19.92,87.9 20.41,87.9 20.7,88.2 22.55,88.2 24.28,86.47 24.28,85.37 24.23,85.32 v1(24.23,85.32) 24.23,85.32 24.23,85.09 24.95,84.36 v1(26.28,84.36) 26.7,83.94 26.7,83.04 28.37,81.37 28.37,76.18 28.95,75.6 33.13,75.6 34.42,74.32 35.42,74.32 38.02,71.72 38.02,70.62 v1(37.95,70.54)
  BOTTOM w0.112: JSSD1.54 v1(26.13,27.62)
PCIE_WAKE#_R: length 8.6
  TOP w0.112: v2(74.19,138.34) 74.77,137.75 v1(74.77,136.42) 74.4,136.42 RW10.2
  BOTTOM w0.112: JWLAN1.55 76.06,134.15 74.9,135.31 74.9,136.29 v1(74.77,136.42)
PECI_EC: length 186.5
  TOP w0.112: DE1.1 37.59,86.91 RE27.2 37.63,87.7 37.89,87.96 37.89,88.42 v1(37.75,88.56)
  IN1 w0.119: v1(141.39,71.91) 140.6,72.69 140.6,95.24 140.93,95.57 140.93,102.16 138.94,104.16 134.11,104.16 132.77,105.5 131.56,105.5 129.95,107.12 127.03,107.12 122.27,111.88 111.49,111.88 109.98,113.39 104.06,113.39 103.29,112.61 96.5,112.61 93.06,116.06 91.52,116.06 v1(90.55,117.03) ; v1(52.65,123.09) 49.4,123.09 47.21,120.89 47.21,118.93 42.65,114.37 42.65,106.16 46.85,101.96 46.85,101.29 44.42,98.86 39.28,98.86 36.61,96.2 36.61,91.83 37.71,90.73 37.71,89.11 37.75,89.07 v1(37.75,88.56)
  IN3 w0.135: v1(90.55,117.03) 90.48,117.11 88.48,117.11 86.09,119.5 76.89,119.5 75.52,120.87 70.05,120.87 69.76,120.58 68.74,120.58 68.07,121.25 58.72,121.25 58.41,121.56 53.91,121.56 52.65,122.82 v1(52.65,123.09)
  BOTTOM w0.102: UC1.AR1 140.5,72.09
  BOTTOM w0.112: 140.5,72.09 140.82,72.09 140.99,71.91 v1(141.39,71.91)
PEG_CRX_C_GTX_N5: length 4.7
  BOTTOM w0.076: 114.73,144.79 114.74,144.79 114.74,144.76 114.78,144.72 114.78,144.69 115.02,144.46 115.02,143.93 114.93,143.84 114.93,143.73 115.03,143.63 115.17,143.63 UV1.AG31
  BOTTOM w0.112: 114.73,144.79 113.78,145.75 113.78,147.18 CV2.2
PEG_CRX_C_GTX_N6: length 5.2
  BOTTOM w0.076: UV1.AF28 115.85,142.89 115.85,143.97 115.52,144.3 115.52,144.7 115.48,144.74 115.48,144.75 115.47,144.75
  BOTTOM w0.112: 115.47,144.75 115.09,145.14 115.09,147.09 CV4.2
PEG_CRX_C_GTX_N7: length 2.5
  TOP w0.102: CV6.2 116.13,141.61 116.13,141.09 116.13,141.05 v1(115.75,140.68)
  BOTTOM w0.102: v1(115.75,140.68) 115.65,140.78 115.65,141.18 115.76,141.28 115.95,141.28 116.14,141.09 UV1.AF26
PEG_CRX_C_GTX_N8: length 3.5
  TOP w0.102: CV8.2 118.63,142.75 118.63,142.51 118.75,142.39 118.75,141.1 118.47,140.82 118.26,140.82 118.11,140.67 v1(118.11,140.62)
  BOTTOM w0.102: v1(118.11,140.62) 118.11,140.63 UV1.AD26
PEG_CRX_C_GTX_P5: length 4.7
  BOTTOM w0.076: 114.58,144.64 114.83,144.38 114.83,144 114.75,143.92 114.75,143.6 UV1.AH30
  BOTTOM w0.112: 114.58,144.64 114.57,144.64 113.55,145.66 113.55,147.04 CV1.2
PEG_CRX_C_GTX_P6: length 5.2
  BOTTOM w0.076: UV1.AG29 115.34,142.94 115.43,142.86 115.59,142.86 115.66,142.93 115.66,143.89 115.34,144.22 115.34,144.58 115.32,144.6
  BOTTOM w0.112: 115.32,144.6 115.3,144.62 114.87,145.05 114.87,147.13 CV3.2
PEG_CRX_C_GTX_P7: length 2.5
  TOP w0.102: CV5.2 116.34,141.47 116.34,141.09 116.34,140.85 v1(116.51,140.68)
  BOTTOM w0.102: v1(116.51,140.68) 116.51,141.43 UV1.AF27
PEG_CRX_C_GTX_P8: length 3.5
  TOP w0.102: CV7.2 118.42,142.87 118.42,142.43 118.54,142.31 v4(118.54,141.89) 118.54,141.19 118.38,141.03 118.17,141.03 118.07,141.13 118.07,141.4 v1(118.09,141.42)
  BOTTOM w0.102: UV1.AD27 117.74,141.52 117.84,141.42 v1(118.09,141.42)
PEG_CRX_GTX_N5: length 133.3
  IN3 w0.089: 136.94,61.26 136.93,61.26 136.9,61.23 136.85,61.23 136.83,61.21 136.81,61.21 136.7,61.1 136.7,61.08 136.42,60.81 136.42,59.96 133.98,57.51 131.89,57.51 131.68,57.31 131.68,57.1 v1(131.51,56.92)
  IN3 w0.135: v1(109.65,147.63) 108.79,147.63 108.51,147.36 108.51,145.72 108.11,145.32 105.82,145.32 104.26,143.76 104.26,141.56 102.66,139.95 102.66,136.26 106.44,132.47 106.44,128.11 104.18,125.85 104.18,120.36 105.39,119.16 108.05,119.16 108.78,118.43 123.19,118.43 132.77,108.86 132.77,98.76 139.19,92.34 139.19,87 139.99,86.2 139.99,79.4 139.24,78.64 139.24,76.75 138.86,76.37 138.86,65.48 137.32,63.94 137.32,61.49 137.09,61.26 136.94,61.26
  BOTTOM w0.102: v1(131.51,56.92) 131.51,56.92 131.25,57.18 UC1.BW9
  BOTTOM w0.112: CV2.1 113.66,148.15 113.66,148.38 113.42,148.62 112.87,148.62 111.88,147.63 v1(109.65,147.63)
PEG_CRX_GTX_N6: length 133.9
  IN3 w0.089: v1(132.87,57.94) 132.99,57.94 133.41,58.35 134.23,58.35 135.95,60.06 135.95,60.94 136.75,61.74 136.75,64.46 136.73,64.49 136.73,64.66 136.76,64.7 136.76,64.74 136.77,64.75
  IN3 w0.135: 136.77,64.75 138.18,66.16 138.18,76.65 138.56,77.03 138.56,79.14 139.28,79.87 139.31,79.9 139.31,85.92 138.51,86.72 138.51,92.05 131.73,98.83 131.73,106.14 131.12,106.75 131.12,109.54 127.63,113.03 126.93,113.03 122.94,117.02 109.1,117.02 107.65,118.47 105.1,118.47 103.5,120.07 103.5,126.25 105.76,128.5 105.76,132.19 101.98,135.97 101.98,140.24 103.58,141.84 103.58,144.04 105.54,146 107.64,146 107.83,146.2 107.83,148.29 108.45,148.9 111.03,148.9 v1(111.23,149.09)
  BOTTOM w0.102: v1(132.87,57.94) 133.2,58.27 UC1.BU6
  BOTTOM w0.112: v1(111.23,149.09) 112.33,149.09 112.61,149.37 114.31,149.37 115.08,148.6 115.08,148.13 CV4.1
PEG_CRX_GTX_N7: length 137
  TOP w0.112: v1(102.23,144.45) 102.46,144.22 102.46,144.01 102.77,143.7 108.37,143.7 110.91,146.24 114.95,146.24 116.34,144.86 116.34,144.13 116.19,143.99 116.19,142.54 CV6.1
  IN3 w0.089: v1(132.78,58.75) 133.01,58.97 133.01,58.97 133.03,58.99 133.03,59.07 133.26,59.29 134.54,59.29 135.49,60.24 135.49,61.04 136.1,61.65 136.1,61.86 136.33,62.09 136.33,65.11 136.46,65.24 136.46,66.16 136.74,66.44 136.74,66.44 136.76,66.47 136.76,66.52 136.77,66.53
  IN3 w0.135: v1(102.23,144.45) 102.39,144.29 102.39,144.27 102.58,144.09 102.58,141.8 101.3,140.52 101.3,135.69 105.08,131.91 105.08,128.79 102.82,126.53 102.82,119.79 105.26,117.35 107.81,117.35 108.81,116.34 122.66,116.34 126.65,112.35 127.35,112.35 130.44,109.26 130.44,106.47 131.05,105.86 131.05,98.55 137.33,92.26 137.33,90.86 137.79,90.4 137.79,89.43 136.99,88.63 136.99,87.27 138.63,85.63 138.63,80.18 138.6,80.15 137.87,79.42 137.87,77.31 137.5,76.94 137.5,69.58 137.04,69.12 137.04,66.8 136.77,66.53
  BOTTOM w0.102: UC1.BT7 132.83,58.94 132.83,58.8 v1(132.78,58.75)
PEG_CRX_GTX_N8: length 140.3
  TOP w0.112: v1(107.34,147.01) 107.52,146.83 109.02,146.83 109.21,146.64 109.91,146.64 110.4,147.12 116.52,147.12 118.91,144.74 CV8.1
  IN3 w0.089: v1(130.84,57.84) 131.02,58.02 131.02,58.22 133.04,60.25 134.21,60.25 134.43,60.46 134.43,60.85 135.94,62.36 135.94,65.91 136.05,66.02 136.05,66.35 136.23,66.53 136.23,66.74 136.18,66.8
  IN3 w0.135: v1(107.34,147.01) 107.15,146.82 105.33,146.82 104.26,145.75 102.04,145.75 101,144.71 101,141.18 100.62,140.8 100.62,135.41 101.02,135.01 104.4,131.63 104.4,129.07 102.14,126.81 102.14,119.51 104.98,116.67 107.53,116.67 108.53,115.66 122.38,115.66 126.37,111.67 127.06,111.67 129.71,109.02 129.71,106.23 130.37,105.58 130.37,98.09 135.1,93.36 135.1,92.71 136.25,91.56 136.25,90.92 137.11,90.06 137.11,89.73 136.25,88.86 136.25,86.66 136.91,86 136.91,83.25 137.41,82.75 137.41,79.92 137.19,79.71 137.19,77.59 136.18,76.58 136.18,66.8
  BOTTOM w0.076: v1(130.84,57.84) 131.25,58.25 UC1.BU9
PEG_CRX_GTX_P5: length 133.3
  IN3 w0.089: v1(132.16,56.94) 131.94,56.94 131.86,57.01 131.86,57.02 131.86,57.02 131.86,57.23 131.96,57.34 134.05,57.34 136.61,59.9 136.61,60.73 136.89,61.01 136.89,61.02 136.94,61.02
  IN3 w0.135: 136.94,61.02 137.19,61.02 137.56,61.39 137.56,63.84 139.1,65.38 139.1,76.27 139.48,76.65 139.48,78.54 140.23,79.3 140.23,86.3 139.43,87.1 139.43,92.44 133.01,98.86 133.01,108.96 123.29,118.67 108.88,118.67 108.15,119.4 105.49,119.4 104.43,120.46 104.43,125.75 106.68,128.01 106.68,132.57 102.9,136.36 102.9,139.85 104.5,141.46 104.5,143.66 105.92,145.08 108.21,145.08 108.76,145.62 108.76,147.26 108.89,147.39 109.11,147.39 109.46,147.05 v1(109.65,147.05)
  BOTTOM w0.102: UC1.BW8 131.9,57.2 v1(132.16,56.94)
  BOTTOM w0.112: v1(109.65,147.05) 109.78,146.92 109.97,146.92 110.08,147.03 110.08,147.3 110.19,147.41 111.97,147.41 112.96,148.4 113.33,148.4 113.44,148.29 113.44,148.06 CV1.1
PEG_CRX_GTX_P6: length 133.9
  IN3 w0.089: 136.94,64.57 136.94,64.55 136.93,64.54 136.93,61.67 136.13,60.87 136.13,59.99 134.31,58.17 133.62,58.17 133.51,58.07 v1(133.51,57.93)
  IN3 w0.135: 136.94,64.57 138.42,66.06 138.42,76.55 138.8,76.93 138.8,79.04 139.53,79.77 139.55,79.8 139.55,86.02 138.75,86.82 138.75,92.15 131.97,98.93 131.97,106.24 131.36,106.85 131.36,109.64 127.73,113.27 127.03,113.27 123.04,117.27 109.2,117.27 107.75,118.72 105.2,118.72 103.74,120.18 103.74,126.15 106,128.4 106,132.29 102.22,136.07 102.22,140.14 103.82,141.74 103.82,143.94 105.64,145.76 107.74,145.76 108.08,146.1 108.08,148.19 108.55,148.66 111.37,148.66 111.48,148.55 111.48,148.36 111.35,148.23 v1(111.25,148.23)
  BOTTOM w0.102: UC1.BU5 133.85,58.27 v1(133.51,57.93)
  BOTTOM w0.112: v1(111.25,148.23) 111.43,148.23 111.67,148.47 111.67,148.76 111.78,148.87 112.42,148.87 112.7,149.15 114.22,149.15 114.86,148.51 114.86,148.09 114.8,148.03 114.8,148.03 CV3.1
PEG_CRX_GTX_P7: length 137
  TOP w0.112: v1(102.82,144.45) 102.74,144.37 102.74,144.36 102.72,144.34 102.72,144.33 102.68,144.29 102.68,144.1 102.86,143.92 108.27,143.92 110.81,146.46 115.05,146.46 116.56,144.95 116.56,144.04 116.41,143.9 116.41,142.54 CV5.1
  IN3 w0.089: 136.94,66.36 136.91,66.36 136.64,66.09 136.64,65.17 136.51,65.04 136.51,62.01 136.28,61.78 136.28,61.58 135.67,60.97 135.67,60.17 134.62,59.11 133.33,59.11 133.21,58.99 133.21,58.8 133.29,58.71 v1(133.46,58.71)
  IN3 w0.135: 136.94,66.36 137.03,66.45 137.04,66.45 137.28,66.69 137.28,69.02 137.74,69.48 137.74,76.84 138.12,77.21 138.12,79.32 138.87,80.08 138.87,85.73 137.24,87.37 137.24,88.53 138.03,89.33 138.03,90.5 137.57,90.96 137.57,92.37 131.29,98.65 131.29,105.96 130.68,106.57 130.68,109.36 127.45,112.59 126.75,112.59 122.76,116.59 108.91,116.59 107.91,117.59 105.36,117.59 103.06,119.89 103.06,126.43 105.32,128.69 105.32,132.01 101.54,135.79 101.54,140.42 102.82,141.7 v1(102.82,144.45)
  BOTTOM w0.102: v1(133.46,58.71) 133.46,58.71 133.2,58.97 UC1.BT6
PEG_CRX_GTX_P8: length 140.3
  TOP w0.112: v1(107.34,146.42) 107.52,146.6 108.93,146.6 109.12,146.42 110.01,146.42 110.49,146.9 116.43,146.9 118.69,144.65 118.69,144.21 118.57,144.1 118.18,144.1 118.07,143.99 118.07,143.81 CV7.1
  IN3 w0.089: v1(131.61,57.84) 131.29,57.84 131.2,57.93 131.2,58.15 133.12,60.07 134.29,60.07 134.6,60.38 134.6,60.78 136.12,62.29 136.12,65.83 136.23,65.95 136.23,66.28 136.41,66.46 136.41,66.82 136.41,66.82
  IN3 w0.135: v1(107.34,146.42) 107.18,146.58 105.43,146.58 104.36,145.51 102.14,145.51 101.24,144.61 101.24,141.08 100.86,140.7 100.86,135.51 101.12,135.25 104.64,131.73 104.64,128.97 102.38,126.71 102.38,119.61 105.08,116.91 107.63,116.91 108.63,115.9 122.48,115.9 126.47,111.91 127.16,111.91 129.96,109.12 129.96,106.33 130.61,105.68 130.61,98.19 135.34,93.46 135.34,92.81 136.49,91.66 136.49,91.02 137.35,90.16 137.35,89.63 136.49,88.76 136.49,86.76 137.15,86.1 137.15,83.35 137.65,82.85 137.65,79.82 137.44,79.61 137.44,77.49 137.24,77.3 137.24,77.3 136.41,76.48 136.41,66.82
  BOTTOM w0.076: UC1.BU8 131.9,58.14 v1(131.61,57.84)
PEG_CTX_C_GRX_N5: length 3.2
  BOTTOM w0.102: 116.59,144.78 116.59,144.69 116.67,144.61 116.67,143.98 116.6,143.91 116.6,143.74 116.69,143.65 116.79,143.65 UV1.AE31
  BOTTOM w0.112: 116.59,144.78 116.59,144.95 116.39,145.15 116.39,146.1 CV10.1
PEG_CTX_C_GRX_N6: length 4.1
  BOTTOM w0.102: UV1.AD28 117.51,142.83 117.51,143.2 117.44,143.27 117.44,143.52 117.46,143.54 117.46,144.02 117.37,144.1 117.37,144.72 117.35,144.73
  BOTTOM w0.112: 117.35,144.73 117.35,145.26 117.78,145.68 117.78,146.08 CV12.1
PEG_CTX_C_GRX_N7: length 3.6
  BOTTOM w0.102: UV1.AC31 118.54,143.74 118.42,143.62 118.29,143.62 118.2,143.71 118.2,143.92 118.49,144.21 118.49,144.78
  BOTTOM w0.112: 118.49,144.78 118.49,144.94 119.2,145.64 119.2,146.11 CV14.1
PEG_CTX_C_GRX_N8: length 5
  BOTTOM w0.102: UV1.AB28 119.1,142.84 119.1,143.2 119.04,143.26 119.04,143.52 119.06,143.54 119.06,144.01 119,144.07 119,144.3 119.15,144.45 119.15,144.69 119.15,144.69 119.15,144.78 119.16,144.78
  BOTTOM w0.112: CV16.1 120.62,146.13 120.62,145.6 120.19,145.17 119.55,145.17 119.16,144.78
PEG_CTX_C_GRX_P5: length 3.2
  BOTTOM w0.102: 116.37,144.78 116.37,144.76 116.37,144.76 116.37,144.69 116.38,144.69 116.38,144.61 116.46,144.52 116.46,144.07 116.39,144 116.39,143.65 UV1.AF30
  BOTTOM w0.112: 116.37,144.78 116.37,144.86 116.17,145.05 116.17,146.09 CV9.1
PEG_CTX_C_GRX_P6: length 4.1
  BOTTOM w0.102: UV1.AE29 117.08,142.86 117.2,142.86 117.3,142.95 117.3,143.11 117.22,143.18 117.22,143.61 117.24,143.63 117.24,143.93 117.16,144.02 117.16,144.61 117.15,144.63
  BOTTOM w0.112: 117.15,144.63 117.13,144.64 117.13,145.35 117.55,145.77 117.55,146.1 CV11.1
PEG_CTX_C_GRX_P7: length 3.6
  BOTTOM w0.102: UV1.AD30 117.82,143.4 117.99,143.57 117.99,144.01 118.28,144.3 118.28,144.68 118.27,144.69 118.27,144.78
  BOTTOM w0.112: CV13.1 118.98,146.08 118.98,145.74 118.27,145.03 118.27,144.78
PEG_CTX_C_GRX_P8: length 5
  BOTTOM w0.102: 118.94,144.78 118.94,144.53 118.79,144.38 118.79,143.98 118.85,143.92 118.85,143.63 118.82,143.61 118.82,143.18 118.85,143.16 118.85,143.16 118.89,143.11 118.89,142.97 118.8,142.88 118.66,142.88 UV1.AC29
  BOTTOM w0.112: 118.94,144.78 118.94,144.88 119.46,145.39 120.1,145.39 120.4,145.69 120.4,146.05 CV15.1
PEG_CTX_GRX_N5: length 138.1
  IN3 w0.135: v1(141.35,56.83) 141.35,57.92 143.37,59.94 143.52,59.94 145.08,61.49 145.08,64.73 144.01,65.8 144.01,69.17 141.81,71.37 141.81,76.9 142.18,77.27 142.18,87.11 141.38,87.91 141.38,94.26 140.67,94.97 140.67,102.24 135.15,107.77 134.84,107.77 123.45,119.16 113.11,119.16 112.05,120.21 112.05,121.51 108.05,125.51 108.05,127.8 107.12,128.72 107.12,132.79 103.34,136.57 103.34,139.67 104.94,141.27 104.94,143.48 106.11,144.64 108.4,144.64 113.11,149.35 116.27,149.35 116.54,149.07 116.54,148.46 v1(116.57,148.44)
  BOTTOM w0.076: UC1.BW4 134.77,57.45 134.93,57.28 135.01,57.28 135.1,57.19 135.4,57.19 135.57,57.36 135.57,57.54 135.68,57.66 135.8,57.71 135.99,57.71 136.08,57.68 136.36,57.68 136.46,57.71 136.7,57.71 136.87,57.54 137.27,57.54 137.28,57.53 137.35,57.53 137.36,57.53 137.52,57.53 137.57,57.58
  BOTTOM w0.102: 137.57,57.58 138.02,58.03 141.18,58.03 141.61,57.6 141.61,57.09 v1(141.35,56.83)
  BOTTOM w0.112: v1(116.57,148.44) 116.39,148.25 116.39,147.09 CV10.2
PEG_CTX_GRX_N6: length 135.5
  IN3 w0.135: v1(142.45,57.87) 142.67,58.09 142.67,58.28 142.95,58.55 143.2,58.55 145.76,61.11 145.76,65.01 144.69,66.08 144.69,69.45 142.49,71.65 142.49,76.07 143.34,76.92 143.34,86.92 142.62,87.64 142.62,93.99 141.36,95.25 141.36,102.53 135.43,108.45 135.12,108.45 123.33,120.24 114.65,120.24 109.64,125.26 109.64,130.29 107.8,132.12 107.8,133.08 104.02,136.86 104.02,139.39 105.62,140.99 105.62,143.19 106.39,143.96 108.68,143.96 111.75,147.03 114.44,147.03 115.03,147.62 116.35,147.62 117.08,148.34 117.64,148.34 117.92,148.07 117.92,147.71 v1(118.12,147.51)
  BOTTOM w0.076: UC1.BU4 135.11,58.48 135.42,58.48 135.76,58.33 136.02,58.33 136.11,58.37 136.33,58.37 136.43,58.33 136.77,58.33 136.96,58.52 142.28,58.52 142.45,58.36 v1(142.45,57.87)
  BOTTOM w0.102: CV12.2 117.8,147.08 117.8,147.32 117.98,147.51 v1(118.12,147.51)
PEG_CTX_GRX_N7: length 132.4
  IN3 w0.135: v1(119.2,148.61) 119.19,148.61 118.92,148.34 118.84,148.34 118.56,148.06 118.56,146.59 118.32,146.35 112.03,146.35 109.15,143.46 109.15,131.74 110.32,130.57 110.32,125.62 114.89,121.04 124.33,121.04 127.52,117.85 127.52,117.01 135.4,109.13 135.71,109.13 142.04,102.81 142.04,95.53 143.3,94.27 143.3,88.1 144.02,87.38 144.02,76.63 143.17,75.78 143.17,71.93 145.37,69.73 145.37,66.36 146.55,65.17 146.55,60.85 144.74,59.04 144.74,58.49 144.6,58.35 v1(144.05,58.35)
  BOTTOM w0.076: 143.37,58.45 143.35,58.46 143.31,58.46 142.76,59.01 136.44,59.01 UC1.BU2
  BOTTOM w0.112: CV14.2 119.39,147.28 119.96,147.85 119.96,148.29 119.72,148.53 119.28,148.53 v1(119.2,148.61) ; v1(144.05,58.35) 143.46,58.35 143.37,58.45
PEG_CTX_GRX_N8: length 134.5
  IN3 w0.135: v1(145.4,58.2) 146.43,58.2 147.48,59.25 147.48,65.55 146.29,66.74 146.29,70.12 144.09,72.31 144.09,75.4 144.94,76.25 144.94,87.76 144.22,88.48 144.22,97.82 142.96,99.08 142.96,103.19 136.1,110.05 135.78,110.05 130.59,115.25 130.59,117.98 128.86,119.71 127.06,119.71 124.39,122.38 115.11,122.38 112.23,125.26 112.23,130.01 110.08,132.16 110.08,143.09 112.41,145.42 120.15,145.42 120.78,146.05 v1(120.78,147.5)
  BOTTOM w0.076: 143.37,59.38 142.04,59.38 141.83,59.18 136.25,59.18 136.21,59.14 135.92,59.14 135.75,59.07 135.47,59.07 UC1.BT4
  BOTTOM w0.112: CV16.2 120.62,147.05 120.62,147.34 v1(120.78,147.5) ; v1(145.4,58.2) 145.27,58.33 144.97,58.33 143.91,59.38 143.37,59.38
PEG_CTX_GRX_P5: length 138.1
  IN3 w0.135: v1(141.93,56.83) 142.04,56.83 142.17,56.96 142.17,57.23 142.04,57.36 141.72,57.36 141.59,57.49 141.59,57.82 143.47,59.7 143.62,59.7 145.32,61.39 145.32,64.83 144.25,65.9 144.25,69.27 142.05,71.47 142.05,76.8 142.43,77.17 142.43,87.21 141.62,88.01 141.62,94.36 140.92,95.07 140.92,102.34 135.25,108.01 134.94,108.01 123.55,119.4 113.21,119.4 112.29,120.31 112.29,121.61 108.29,125.61 108.29,127.9 107.36,128.82 107.36,132.89 103.58,136.67 103.58,139.57 105.19,141.17 105.19,143.38 106.21,144.4 108.5,144.4 113.21,149.11 116.17,149.11 116.3,148.97 116.3,148.77 116.15,148.61 116.15,148.6 v1(115.99,148.44)
  BOTTOM w0.076: UC1.BW3 135,57.45 134.91,57.54 134.91,57.62 134.98,57.7 135.49,57.7 135.59,57.8 135.76,57.88 136.02,57.88 136.11,57.84 136.33,57.84 136.43,57.88 136.77,57.88 136.94,57.71 137.34,57.71 137.35,57.7 137.42,57.7 137.44,57.72
  BOTTOM w0.102: v1(141.93,56.83) 141.8,56.96 141.8,57.68 141.26,58.22 137.95,58.22 137.44,57.72
  BOTTOM w0.112: v1(115.99,148.44) 116.17,148.25 116.17,147.09 CV9.2
PEG_CTX_GRX_P6: length 135.5
  IN3 w0.135: v1(143.03,57.87) 142.91,57.99 142.91,58.18 143.05,58.31 143.3,58.31 146,61.01 146,65.11 144.93,66.18 144.93,69.55 142.73,71.75 142.73,75.97 143.58,76.82 143.58,87.02 142.86,87.74 142.86,94.09 141.6,95.35 141.6,102.63 135.53,108.69 135.22,108.69 123.43,120.48 114.75,120.48 109.88,125.36 109.88,130.39 108.04,132.22 108.04,133.18 104.26,136.96 104.26,139.29 105.87,140.89 105.87,143.09 106.49,143.72 108.78,143.72 111.85,146.78 114.54,146.78 115.13,147.38 116.45,147.38 117.18,148.1 117.54,148.1 117.68,147.97 117.68,147.26 117.6,147.18 117.39,147.18 117.26,147.31 v1(117.26,147.49)
  BOTTOM w0.076: v1(143.03,57.87) 143.03,58.15 142.96,58.22 142.69,58.22 142.61,58.3 142.61,58.43 142.35,58.69 136.89,58.69 136.7,58.5 136.46,58.5 136.36,58.53 136.08,58.53 135.99,58.5 135.8,58.5 135.49,58.63 UC1.BU3
  BOTTOM w0.102: CV11.2 117.38,146.88 117.59,147.09 117.59,147.35 117.45,147.49 v1(117.26,147.49)
PEG_CTX_GRX_P7: length 132.5
  IN3 w0.135: v1(119.2,148.03) 119.13,148.1 118.94,148.1 118.8,147.96 118.8,146.69 118.8,146.49 118.42,146.1 112.13,146.1 109.39,143.36 109.39,131.84 110.56,130.67 110.56,125.72 114.99,121.28 124.43,121.28 127.76,117.95 127.76,117.11 135.5,109.37 135.81,109.37 142.28,102.91 142.28,95.64 143.54,94.37 143.54,88.2 144.26,87.48 144.26,76.53 143.41,75.68 143.41,72.03 145.61,69.83 145.61,66.46 146.79,65.27 146.79,60.75 144.98,58.94 144.98,58.39 144.7,58.11 144.57,58.11 144.46,58 144.46,57.83 144.32,57.69 144.13,57.69 v1(144.05,57.77)
  BOTTOM w0.076: UC1.BU1 136.64,58.85 142.69,58.85 143.2,58.34 143.2,58.3 143.21,58.29
  BOTTOM w0.112: v1(144.05,57.77) 144.05,57.7 143.94,57.59 143.72,57.59 143.61,57.7 143.61,58.03 143.51,58.13 143.37,58.13 143.21,58.29 ; v1(119.2,148.03) 119.49,148.31 119.62,148.31 119.74,148.2 119.74,147.94 119.17,147.37 119.17,147.3 CV13.2
PEG_CTX_GRX_P8: length 134.5
  IN3 w0.135: v1(120.2,147.5) 120.14,147.44 120.14,147.2 120.28,147.06 120.42,147.06 120.54,146.94 120.54,146.15 120.05,145.66 112.31,145.66 109.84,143.19 109.84,132.06 111.99,129.91 111.99,125.16 115.01,122.14 124.29,122.14 126.96,119.46 128.76,119.46 130.35,117.88 130.35,115.15 135.68,109.81 136,109.81 142.72,103.09 142.72,98.98 143.98,97.72 143.98,88.38 144.7,87.66 144.7,76.35 143.85,75.5 143.85,72.21 146.05,70.02 146.05,66.64 147.23,65.45 147.23,59.35 146.33,58.44 145.74,58.44 v1(145.4,58.78)
  BOTTOM w0.076: UC1.BT3 135.5,59.39 135.5,59.5 135.65,59.65 135.76,59.65 135.87,59.54 135.87,59.38 135.95,59.3 136.14,59.3 136.18,59.34 141.76,59.34 141.97,59.55 143.27,59.55 143.29,59.57 143.32,59.57 143.36,59.6 143.37,59.6
  BOTTOM w0.112: CV15.2 120.4,147.13 120.4,147.3 120.38,147.33 v1(120.2,147.5) ; 143.37,59.6 144,59.6 145.06,58.55 145.18,58.55 145.4,58.77 v1(145.4,58.78)
PHASE_VCORE1:
  vias: v2(165.27,67.51)
PHASE_VCORE2:
  vias: v2(167.9,84.74)
PHASE_VGT1:
  vias: v2(161.96,96.12)
PLL_ANALOG_IN: length 4.1
  BOTTOM w0.102: 119.73,122.19 UV1.AA1
  BOTTOM w0.112: 119.73,122.19 118.92,121.38 118.92,120.46 118.74,120.28 118.74,119.29 TP74.1
PLL_ANALOG_OUT: length 4.4
  BOTTOM w0.102: UV1.AA3 120.45,123.09 120.45,122.19
  BOTTOM w0.112: RV83.1 119.64,119.73 v2(119.64,120.52) 119.64,121.39 120.45,122.19
PLT_RST_VGA#: length 155.6
  TOP w0.112: UE1.23 46.15,68.95 v1(45.93,69.17) ; UV3.1 v2(64.5,123.49) v1(65.31,123.49)
  IN2 w0.124: v1(106.71,119.97) 106.71,117.52 103.1,113.91 87.53,113.91 85.3,116.15 68.73,116.15 67.73,117.15 67.73,121.07 v1(65.31,123.49) 59.84,123.49 54.26,117.91 52.61,117.91 50.88,116.19 v1(50.42,116.19)
  IN3 w0.135: v1(49.56,94.42) 47.91,92.77 47.91,84.73 47.07,83.89 47.07,79.47 46.38,78.77 46.38,69.62 v1(45.93,69.17)
  BOTTOM w0.112: v1(50.42,116.19) 50.25,116.19 43.6,109.53 43.6,103.44 49.56,97.47 v1(49.56,94.42) ; UV1.AL27 112.87,141.33 112.67,141.33 110.91,139.57 110.91,138.79 RV4.1 109.6,138.73 108.32,138.73 108.21,138.62 108.21,133.52 107.59,132.9 107.59,131.1 106.79,130.3 106.79,128.88 106.08,128.17 106.08,127.83 106.08,126.62 107.51,125.19 107.51,123.22 108.1,122.63 UV2.4 108.1,121.46 107.6,120.96 107.6,120.86 v1(106.71,119.97)
PLTRST#: length 360.6
  TOP w0.089: 25.06,85.42 25.06,85.07 24.91,84.92
  TOP w0.102: UL1.19 24.8,84.8 24.91,84.92
  TOP w0.112: v1(110.65,113.28) 110.65,112.9 120.75,102.8 v1(120.75,100.45) ; v1(110.14,119.95) 109.67,119.47 102.29,119.47 99.84,117.03 98.65,117.03 97.52,118.16 v2(82.55,118.16) 79.26,118.16 v1(79.03,118.39) ; RE65.1 v1(46.87,97.38) ; v1(83.85,37.78) 83.85,37.65 84.14,37.37 UX1.17 ; v1(25.06,85.75) 25.06,85.75 25.06,85.42 ; v1(93.04,45.97) 93.04,46.18 91.78,47.45 91.78,52.07 92.03,52.33 92.03,53.45 93.26,54.68 CC75.1 RC94.1 94.59,54.94 UC4.4
  IN1 w0.119: v1(46.87,97.38) 46.87,97.72 50.62,101.47 50.62,112.12 53.88,115.37 53.88,116.27 57.61,120 v1(57.61,120.12) 57.61,120.54 62.53,125.46 62.53,130.31 63.05,130.82 63.05,132.99 v1(62.88,133.15) ; v1(27.13,27.62) 27.13,27.36 25.04,25.28 20.29,25.28 18.55,27.02 18.55,31.06 19.63,32.14 19.63,32.15 19.72,32.24 19.72,41.18 19.94,41.4 19.94,41.42 20.83,42.31 20.83,43.6 22.07,44.84 22.07,51.14 22.39,51.46 22.39,57.27 24.13,59.01 24.13,63.52 24.64,64.02 24.64,75.66 24.09,76.21 24.09,78.78 25.84,80.52 25.84,85.51 25.6,85.75 v1(25.06,85.75)
  IN3 w0.135: v1(46.87,97.38) 42.62,97.38 41.26,96.03 41.26,91.62 40.32,90.68 39.12,90.68 38.19,89.75 38.19,88.32 37.3,87.43 34.58,87.43 34.2,87.05 32.55,87.05 32.04,87.56 29.59,87.56 28.03,86 25.31,86 v1(25.06,85.75) ; v1(79.03,118.39) 71.77,118.39 71.39,118.01 68.58,118.01 67.08,119.5 58.22,119.5 v1(57.61,120.12)
  BOTTOM w0.112: JSSD1.50 v1(27.13,27.62) ; v1(120.75,100.45) 120.75,102.61 119.12,104.24 116.88,104.24 114.15,106.97 106.34,106.97 99.89,100.53 99.89,63.83 92.55,56.49 92.55,52.76 93.64,51.67 93.64,49.72 91.24,47.32 91.24,45.92 91.53,45.63 92.7,45.63 v1(93.04,45.97) 93.04,46.17 93.38,46.51 94.07,46.51 94.38,46.81 95.39,46.81 95.7,46.5 95.7,44.4 94.6,43.3 92.85,43.3 92.32,42.77 92.07,42.77 90.55,41.25 88.3,39 86.98,39 86.85,38.87 84.61,38.87 83.85,38.11 v1(83.85,37.78) ; UV2.1 109.4,120.19 109.64,119.95 v1(110.14,119.95) 110.65,119.44 v1(110.65,113.28) ; JWLAN1.52 63.12,133.4 v1(62.88,133.15)
POK: length 381.1
  TOP w0.112: v1(92.46,46.01) 92.46,46.18 91.56,47.08 91.56,52.36 v2(91.72,52.51) 91.72,53.72 93.84,55.84 RC105.1 CC14.1 93.85,56.83 94.86,57.84 UC5.2
  TOP w0.254: DZ2.1 69.84,30.92 v1(69.26,30.92) 69.26,30.49 68.74,29.97 68.74,26.73 68.42,26.41 67.41,26.41 v1(67.22,26.22) ; PR35.1 207.96,50.2 207.96,51.29 207.7,51.55 v1(207.32,51.55) ; PR304.2 18.94,44.5 v1(18.4,44.5)
  IN1 w0.254: v1(18.4,44.5) 18.63,44.5 18.89,44.76 18.89,45.59 19.52,46.21 19.52,56.43 22.35,59.27 22.35,62.14 24.35,64.14 24.35,75.02 20.35,79.01 20.35,81.7 20.63,81.97 21.37,81.97 22.04,82.65 22.04,85.38 27.01,90.34 27.01,91.61 v1(28.61,93.21)
  IN2 w0.124: v1(215.86,49.19) 214.41,50.64 214.41,54.29 213.78,54.92 212.76,54.92 212.38,54.54 212.38,51.87 212.05,51.55 v1(207.32,51.55) ; v1(215.27,40.11) 214.7,39.54 214.7,38.53 212.44,36.27 212.44,35.98 211.61,35.15 208.49,35.15 206.5,33.16 203.92,33.16 203.73,33.34 200.98,33.34 200.44,32.81 198.88,32.81 198.57,33.13 189.61,33.13 189.05,32.57 180.21,32.57 176.07,28.43 174.81,28.43 174.16,27.78 172.97,27.78 171.23,29.52 167.12,29.52 165.52,27.92 159.64,27.92 159.23,27.51 150.39,27.51 149.01,28.89 147.8,28.89 144.65,32.03 136.66,32.03 133.51,28.89 129.32,28.89 127.92,27.49 124.25,27.49 123.72,26.96 101.42,26.96 100.14,25.68 67.76,25.68 v1(67.22,26.22) ; v1(86.52,31.43) 85.84,30.75 80.26,30.75 79.07,31.94 76.8,31.94 76.37,31.52 69.86,31.52 v1(69.26,30.92)
  IN3 w0.135: v1(215.27,40.11) 216,40.84 216,44.05 215.46,44.59 215.46,45.47 215.86,45.87 v1(215.86,49.19)
  IN3 w0.254: v1(67.22,26.22) 67.22,25.9 66.84,25.52 63.02,25.52 62.65,25.89 61.2,25.89 60.94,26.14 60.94,26.73 57.87,29.8 57.18,29.8 55.51,31.47 48.46,31.47 47.94,32 47.94,33.02 46.52,34.44 42.31,34.44 39.33,37.42 39.33,40.88 37.6,42.6 34.64,42.6 33.65,41.61 31.69,41.61 31.23,41.15 22.42,41.15 19.01,44.56 18.45,44.56 v1(18.4,44.5)
  BOTTOM w0.112: v1(86.52,31.43) 87.36,31.43 87.47,31.54 87.47,32.04 86.43,33.08 86.43,37.89 87.33,38.79 88.39,38.79 92.15,42.55 92.41,42.55 92.94,43.09 94.69,43.09 95.91,44.31 95.91,46.72 95.58,47.05 94.31,47.05 93.98,46.72 93.17,46.72 v1(92.46,46.01)
  BOTTOM w0.203: PU501.9 27.63,96.72 27.97,96.37 27.97,93.71 28.47,93.21 v1(28.61,93.21) 29.26,93.21 PR504.2
  BOTTOM w0.254: PU301.9 17.92,43.49 17.66,43.74 17.66,44.1 18.07,44.5 v1(18.4,44.5)
POWER_SW#_MB: length 263.5
  TOP w0.112: v1(222.24,64.93) 222.04,65.13 ED1.3 EC1.1 219.11,63.75 223.65,59.21 v2(223.65,53.36) 223.65,53.23 221.57,51.15 v1(221.23,51.15) ; RE25.2 32.04,64.57 32.04,63.35 v1(31.88,63.2) 31.22,62.54 SW1.1
  IN2 w0.124: v1(31.88,63.2) 32.4,62.68 39.72,62.68 41.31,61.09 42.2,61.09 45.15,58.13 45.15,54.72 44.22,53.79 44.22,39.07 50.12,33.18 54.4,33.18 59.62,27.96 60.09,27.96 61.24,26.8 66.01,26.8 66.62,27.41 67.69,27.41 68.59,26.51 99.79,26.51 101.78,28.5 115.71,28.5 116.97,29.77 122.73,29.77 123.82,28.67 127.83,28.67 128.92,29.77 132,29.77 135.11,32.87 145,32.87 145.92,31.95 148.09,29.78 150.02,29.78 150.53,29.27 150.9,29.27 151.82,28.35 158.88,28.35 159.33,28.8 165.17,28.8 166.79,30.41 171.99,30.41 173.05,29.35 175.82,29.35 179.86,33.4 188.71,33.4 189.27,33.96 197.75,33.96 198.63,34.84 207.03,34.84 208.39,36.2 211.82,36.2 214.47,38.85 214.47,40.12 215.05,40.7 217.81,40.7 219.82,42.72 219.82,49.75 v1(221.23,51.15)
  BOTTOM w0.112: JPWR1.2 v1(222.24,64.93)
POWER_SW_IN#: length 8.3
  TOP w0.112: UE1.127 34.91,69.81 34.59,69.49 34.59,67.08 34.06,66.54 33.57,66.54 CE14.1 32.43,66.11 RE20.2 RE25.1 32.32,64.33 v2(32.5,64.16)
PRIM_PWRGD: length 284.8
  TOP w0.112: v1(44.77,105.5) 43.47,104.2 43.47,103.94 v1(41.56,102.04) ; v1(200.31,57.2) 201,57.2 201.52,57.72 v3(201.52,58.24) 201.52,59.62 198.79,62.35 197.07,62.35 196.06,61.34 193.33,61.34 192.27,62.39 v1(188.62,62.39) ; v1(44.42,71.94) 44.83,71.53 45.94,71.53 48.17,69.3 48.38,69.3 48.95,68.73 UE1.30
  TOP w0.254: v1(168.51,47.07) 168.98,46.6 168.98,45.58 167.56,44.15 166.24,44.15 PRH01.1
  IN2 w0.124: v1(44.77,105.5) 46.01,106.74 49.24,106.74 56.39,113.9 85.54,113.9 87.56,111.88 113,111.88 114.87,113.75 119.48,113.75 120.41,112.81 122.55,112.81 123.07,112.3 128.91,112.3 131.71,109.5 135.26,109.5 139.42,105.34 143.16,105.34 143.8,105.98 157.26,105.98 168.47,94.76 168.47,89.05 168.98,88.54 168.98,76.73 173.47,72.24 180.7,72.24 181.92,71.02 181.92,68.04 186.91,63.05 188.38,63.05 188.62,62.81 v1(188.62,62.39) 188.62,61.48 188.35,61.21 188.35,59.08 186.19,56.92 186.19,54.41 183.46,51.68 182.34,51.68 177.83,47.18 v1(177.71,47.18) ; v1(41.56,102.04) 44.74,98.86 44.74,93.21 44.29,92.77 44.29,88.9 44.05,88.65 44.05,84.35 43.28,83.58 43.28,76.25 43.76,75.77 43.76,73.04 44.42,72.38 v1(44.42,71.94)
  IN3 w0.135: v1(177.71,47.18) 176.47,47.18 176.46,47.16 176.17,47.16 175.89,46.88 175.51,46.88 174.59,45.96 169.62,45.96 v1(168.51,47.07)
  BOTTOM w0.254: PR1803.2 v1(200.31,57.2) 200.31,55.75 200.67,55.39 PU1801.4
PRIMCORE_VID0: length 4.5
  BOTTOM w0.076: TP28.1 110.47,54.34 112.18,54.34 113.05,55.2 UC1.CB36
PRIMCORE_VID1: length 3.8
  BOTTOM w0.076: TP29.1 112.23,54.62 112.98,55.37 113.92,55.37 114.14,55.46 114.38,55.46 114.62,55.33 114.77,55.33 UC1.CB35
PROCHOT: length 17.2
  TOP w0.112: UE2.2 38.02,89.8 RE45.2 37.12,90.61 v1(37.18,90.67) 37.18,90.74 v2(38.03,91.59) ; v1(41.37,81.54) 41.4,81.54 42.55,82.69 UE1.83
  IN2 w0.124: v1(41.37,81.54) 41.37,82.66 40.89,83.13 40.89,88.28 38.82,90.36 37.5,90.36 v1(37.18,90.67)
PROG_CHG: length 4.3
  BOTTOM w0.112: PRB17.2 203.36,49.63 202.83,50.16 v2(202.83,51.41)
  BOTTOM w0.203: PRB17.2 203.36,49.14 204.03,48.47 PUB01.19
PROH: length 7
  TOP w0.254: v1(207.11,49.46) 207.11,49.8 206.83,50.08 206.02,50.08 PQB33.2 205.28,50.25 PRB21.2 PRB44.2
  BOTTOM w0.203: v1(207.11,49.46) 207.11,48.78 v2(206.96,48.62) 206.9,48.57 205.96,48.57 205.63,48.24 PUB01.23
PROJECT_ID1: length 15
  IN3 w0.135: v1(125.85,50.96) 125.65,50.76 125.65,41.5 124.96,40.81 v1(123.23,40.81)
  BOTTOM w0.076: UC1.CK19 125.45,50.76 125.64,50.95 125.85,50.95 v1(125.85,50.96)
  BOTTOM w0.112: v2(123.23,40.29) v1(123.23,40.81) 123.48,41.06 RC55.1 RC52.2
PROJECT_ID2: length 9.4
  BOTTOM w0.076: UC1.CG17 126.49,52.29 126.21,52.01 126.21,50.54 126.13,50.46 126.13,48.97 126.14,48.96 126.14,47.84 126.06,47.76 v2(126.06,45.31) 125.59,44.84 RC200.2
  BOTTOM w0.112: RC200.2 RC201.1
PROJECT_ID3: length 7.7
  TOP w0.112: RC56.1 RC53.2 124.54,44.33 123.98,44.9 123.98,45.27 124.11,45.4 v1(124.11,45.68) 124.11,45.97 v2(123.9,46.19)
  BOTTOM w0.076: v1(124.11,45.68) 124.36,45.68 124.75,46.06 124.75,47.42 124.33,47.84 124.33,48.73 124.36,48.83 124.5,48.96 124.5,49.12 UC1.CN20
PS_0: length 5.9
  TOP w0.102: RV8.2 115.7,135.17 RV9.1 CV28.1 117.48,135.46 117.82,135.8 v1(118,135.8) 118,135.17 117.97,135.14 117.97,134.32 118.38,133.9 118.51,133.9 v2(118.61,133.8)
  BOTTOM w0.102: v1(118,135.8) 118.54,135.26 UV1.AC19
PS_1: length 5.8
  TOP w0.102: v1(117.33,135.95) 117.12,136.16 CV29.1 116.15,135.64 114.86,135.64 RV12.1 113.9,135.71 RV11.2 113.84,135.69 113.53,136.01 v2(112.9,136.01)
  BOTTOM w0.102: UV1.AD19 117.33,135.61 v1(117.33,135.95)
PS_2: length 4.9
  TOP w0.102: v1(116.6,133.54) 116.6,133.46 116.26,133.13 v2(116.18,133.13) 115.57,133.13 CV30.1 RV14.1 112.82,133.91 RV13.2
  BOTTOM w0.102: UV1.AE17 116.6,133.66 v1(116.6,133.54)
PS_3: length 5.5
  TOP w0.102: 112.45,137.97 RV15.2 RV16.1 CV31.1 115.16,137.71 115.9,137.71 v1(116.67,136.95)
  TOP w0.112: 112.45,137.97 112.4,137.97 v2(112.27,138.1)
  BOTTOM w0.102: v1(116.67,136.95) 116.67,136.67 UV1.AE20
PS_ID: length 77.5
  TOP w0.112: v1(48.93,71.33) 49.82,71.33 50.54,70.61 UE1.36
  TOP w0.254: v1(54.71,129.22) PR1.2 PR5.1 53.97,128.62 53.49,129.1 v2(51.91,129.1) 51.61,129.1 51.09,129.62 PD2.1
  IN1 w0.119: v1(46.9,103.82) 45.88,104.83 45.88,112.96 48.5,115.58 48.5,117.6 51.54,120.64 52.25,120.64 54.26,122.65 54.26,124.58 57.12,127.44 57.12,128.71 56.55,129.28 54.77,129.28 v1(54.71,129.22)
  IN3 w0.135: v1(46.9,103.82) 47.41,103.31 47.41,99.83 48.91,98.33 48.91,96.48 51.11,94.28 51.11,85.61 48.29,82.79 48.29,80.22 48.76,79.76 48.76,78.61 47.42,77.27 47.42,74.34 48.29,73.46 48.29,71.96 v1(48.93,71.33)
PSID: length 55
  TOP w0.112: v1(79.2,142.74) v2(78.77,143.17)
  TOP w0.254: PL3.1 56.1,134.62 v1(56.04,134.68)
  IN1 w0.254: v1(79.2,142.74) 79.2,141.07 77.77,139.63 77.01,139.63 76.06,138.68 76.06,138.58 74.32,136.84 73.6,136.84 73.13,136.38 72.35,136.38 71.02,137.7 67.31,137.7 63.33,133.73 63.33,130.7 62.82,130.19 62.82,125.3 58.08,120.57 v1(58.08,120.46)
  BOTTOM w0.112: v1(58.08,120.46) 58.26,120.64 58.26,122.04 56.99,123.31 56.99,133.73 v1(56.04,134.68)
  BOTTOM w0.254: PJPDC1.3 v1(79.2,142.74)
PSID-1: length 5.8
  TOP w0.254: PR3.2 PR6.1 57.9,135.71 57.76,135.85 v2(56.38,135.85) 56.32,135.85 54.96,134.49 PQ2.2
PSID-2: length 6.6
  TOP w0.112: v2(59.42,132.83) PD1.2
  TOP w0.254: PR3.1 57.12,133.65 PD1.2 56.32,132.83 PL3.2 56,133.15 54.9,133.15 54.64,132.9 PQ1.1
PSID-3: length 3.3
  TOP w0.112: v2(57.13,130.4) 56.99,130.26 PQ1.3
  TOP w0.254: PR1.1 55.62,130.25 PQ1.3
PTP_DIS#: length 138.8
  TOP w0.112: UE1.90 39.75,82.21 40.68,81.28 40.68,79.95 40.19,79.46 40.19,77.13 40.3,77.02 v1(40.36,77.02)
  IN3 w0.135: v1(37.09,61.81) 37.09,61.81 37.12,61.84 37.12,64.19 36.12,65.19 36.12,66.57 38.77,69.22 38.77,73.62 40.74,75.58 40.74,76.45 40.36,76.82 v1(40.36,77.02)
  BOTTOM w0.112: D5.1 116.3,32.88 115.73,32.32 v2(115.73,30.83) 115.73,30.4 114.66,29.32 113.49,29.32 112.65,28.49 109.18,28.49 109.06,28.37 109.06,26.28 108.68,25.9 99.72,25.9 98.77,24.95 66.18,24.95 65.07,26.06 65.07,28.63 64,29.7 60.33,29.7 58.28,31.75 57.75,31.75 54.13,35.36 47.28,35.36 45.75,36.89 43.2,36.89 42.91,37.18 37.57,42.51 37.57,54.4 37.93,54.76 37.93,60.97 v1(37.09,61.81)
