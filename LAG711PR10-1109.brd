# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_PWROK: length 199.3
  TOP w0.112: v1(65.78,124.43) 65.49,124.14 UV3.2 ; RC68.2 88.67,116.68 v1(88.68,116.67) 91.15,114.2 114.68,114.2 121.07,107.82 127.22,107.82 128.18,108.78 131.47,108.78 132.43,107.82 132.43,107.5 v1(133.45,106.48) 133.66,106.7 v3(133.66,107.97) 133.66,108.85 138.15,113.34 139.58,113.34 v1(139.99,112.93)
  TOP w0.254: v1(80.74,122.8) 80.3,122.36 79.74,122.36 PRV20.2
  IN1 w0.089: 128.75,54.67 128.24,54.16 127.88,54.16 127.8,54.07 127.8,53.53 127.54,53.27
  IN1 w0.119: 127.54,53.27 126.65,53.27 126.4,53.02 126.02,53.02 125.01,52.01 122.88,52.01 v1(122.76,52.13) ; v1(125.32,95.56) 125.32,94.93 124.43,94.04 124.11,94.04 122.04,91.97 122.04,87.13 122.94,86.23 122.94,83.6 122.2,82.86 122.2,75.21 122.61,74.8 122.61,74.16 122.16,73.71 122.16,65.17 124,63.34 128.85,63.34 130.12,62.07 130.12,57.43 128.63,55.95 128.63,55.37 128.75,55.25 128.75,54.67
  IN2 w0.124: v1(80.74,122.8) 80.41,122.48 79.93,122.48 76.45,125.95 76.45,131.35 75.61,132.19 75.61,135.26 76.96,136.61 76.96,137.74 76.33,138.37 72.42,138.37 71.99,137.94 67.3,137.94 66.84,137.47 66.84,135.57 68.79,133.61 68.79,130.32 70.39,128.72 70.39,127.95 69.48,127.03 68.38,127.03 v1(65.78,124.43)
  BOTTOM w0.089: v1(122.76,52.13) 122.71,52.18 122.22,52.18 121.3,51.26 UC1.CJ25
  BOTTOM w0.112: PRW01.1 140.06,112.86 v1(139.99,112.93) ; v1(80.74,122.8) 80.74,121.8 81.21,121.33 81.21,120.05 85.25,116.01 88.02,116.01 v1(88.68,116.67) ; v1(133.45,106.48) 133.09,106.13 133.09,104.43 126.29,97.63 126.29,96.81 125.32,95.83 v1(125.32,95.56)
DIFFOUT_2PH_CPU: length 5
  BOTTOM w0.203: PUZ01.2 177.23,52.36 177.69,51.89 179.02,51.89 179.34,51.57 v2(179.34,51.53) 179.34,50.93 179.2,50.79 PRZ21.1 179.2,49.57 PRZ20.1
DIMM_CHA_SA0: length 3.5
  TOP w0.112: RD3.1 69.63,44.21 v1(69.66,44.18) 69.63,44.15 RD2.2 v2(70.52,43.53)
  BOTTOM w0.112: JDIMM1.256 69.72,44.24 v1(69.66,44.18)
DIMM_CHA_SA1: length 5.3
  TOP w0.112: v2(68.02,43.09) 68.48,43.09 68.92,43.53 RD4.2 68.93,44.17 v1(68.91,44.18) 68.93,44.2 RD5.1
  BOTTOM w0.127: v1(68.91,44.18) 68.91,43.37 69.04,43.24 JDIMM1.260
DIMM_CHA_SA2: length 4.4
  TOP w0.112: v2(68.46,66.52) 68.73,66.52 v1(69.02,66.8) 68.87,66.95 RD6.2 68.23,67.52 RD7.1
  BOTTOM w0.102: JDIMM1.166 70.27,66.74 69.88,66.35 69.47,66.35 v1(69.02,66.8)
DIMM_CHB_SA0: length 3.8
  TOP w0.112: RD16.1 57.65,44.76 v1(56.93,44.76) 56.34,44.76 RD15.2 v2(56.33,45.73)
  BOTTOM w0.127: JDIMM2.256 58.25,44.24 57.58,44.24 57.12,44.7 56.99,44.7 v1(56.93,44.76)
DIMM_CHB_SA1: length 4.2
  TOP w0.112: RD18.1 57.4,44.13 57.36,44.17 v1(56.97,44.17) 56.63,44.17 56.59,44.13 RD17.2 v2(56.33,43.2)
  BOTTOM w0.127: v1(56.97,44.17) 56.97,43.77 57.5,43.24 JDIMM2.260
DIMM_CHB_SA2: length 4.4
  TOP w0.112: RD19.2 RD20.1 ; RD20.1 56.89,66.52 v1(56.95,66.58) ; RD20.1 56.27,66.52 55.86,66.11 v2(55.86,65.02)
  BOTTOM w0.112: JDIMM2.166 57.11,66.74 v1(56.95,66.58)
DMIC_CLK: length 2
  TOP w0.112: LA5.2 35.34,11.3 34.62,12.01 UA1.3
DMIC_CLK_EDP: length 244.4
  TOP w0.112: v1(217.27,48.04) 217.43,48.2 218.11,48.2 218.22,48.09 218.22,47.94 218.34,47.82 ED4.3 218.47,47.88 218.47,48.22 218.68,48.43 219.01,48.43 219.12,48.32 219.12,47.84 219.85,47.11 221.19,47.11 v1(221.4,46.91) ; LA5.1 37.03,11.62 38.18,11.62 CA9.1 38.34,11.13 v1(37.88,11.13)
  IN1 w0.119: v1(37.88,11.13) 38.05,10.96 38.52,10.96 39.73,12.16 39.73,17.68 39.06,18.34 39.06,23.71 39.54,24.19 40.55,24.19 41.69,25.33 42.71,25.33 44.87,27.5 44.87,29.53 47.34,32 55.92,32 59.08,28.85 59.08,26.71 v1(59.27,26.53)
  IN3 w0.117: v1(59.27,26.53) 59.1,26.36 59.1,26.01 59.81,25.31 62.42,25.31 62.78,24.95 67.02,24.95 134.8,24.95 140.2,30.35 142.9,30.35 147.7,25.55 176.91,25.55 181.79,30.42 218.64,30.42 220.68,32.47 220.68,37.07 220.48,37.26 220.48,43.33 222.35,45.2 222.35,46.87 222.11,47.1 221.59,47.1 v1(221.4,46.91)
  BOTTOM w0.112: v1(217.27,48.04) 217.11,48.19 215.81,48.19 215.43,47.81 215.43,46.08 214.93,45.58 213.2,45.58 213.07,45.45 JEDP1.31
DMIC_DATA: length 2.1
  TOP w0.112: UA1.2 34.63,11.61 RA4.2
DMIC_DATA_EDP: length 244.6
  TOP w0.112: RA4.1 36.91,10.41 37.23,10.08 38.18,10.08 CA8.1 38.37,10.54 v1(37.88,10.54) ; v1(221.4,47.49) 221.25,47.35 219.95,47.35 219.36,47.94 219.36,48.45 218.99,48.82 ED4.2 218.16,48.44 217.45,48.44 v1(217.27,48.62)
  IN1 w0.119: v1(37.88,10.54) 38.05,10.71 38.63,10.71 39.97,12.06 39.97,17.78 39.31,18.44 39.31,23.61 39.64,23.94 40.65,23.94 41.79,25.09 42.81,25.09 45.12,27.4 45.12,29.43 47.45,31.76 55.82,31.76 58.83,28.74 58.83,26.68 v1(58.68,26.53)
  IN3 w0.117: v1(58.68,26.53) 58.86,26.35 58.86,25.91 59.72,25.05 62.31,25.05 62.67,24.69 67.13,24.69 67.13,24.69 134.91,24.69 140.31,30.09 142.79,30.09 147.57,25.3 177.02,25.3 181.89,30.18 218.74,30.18 220.93,32.37 220.93,37.17 220.73,37.37 220.73,43.23 222.61,45.11 222.61,46.98 222.22,47.37 221.52,47.37 v1(221.4,47.49)
  BOTTOM w0.112: JEDP1.30 213.07,45.95 213.2,45.82 214.83,45.82 215.19,46.17 215.19,47.91 215.71,48.43 217.08,48.43 v1(217.27,48.62)
DP_VSSR: length 1.6
  TOP w0.112: v1(112.07,134.54) v2(111.4,134.54)
  BOTTOM w0.305: UV1.AM18 112.13,134.6 v1(112.07,134.54)
  vias: v1(111.92,137.73) v1(111.92,136.39) v1(112.75,132.33) v1(114.62,131.92) v1(114.95,131.06) v1(115.66,139) v1(116.08,136.94)
DRVON: length 92.2
  TOP w0.112: v1(157.1,95.8) v3(157.1,96.46)
  IN1 w0.254: v1(178.79,59.81) 178.79,60 180.31,61.53 180.31,63.75 178.14,65.92 173.44,65.92 172.91,66.45 172.91,68.23 v1(172.88,68.26) 172.91,68.28 172.91,71.03 168.1,75.84 168.1,88.05 166.95,89.2 v1(165.36,89.2)
  IN1 w0.305: v1(165.36,89.2) 165.36,88.76 164.97,88.37 160.84,88.37 160.44,88.78 160.44,89.96 160.04,90.36 158.17,90.36 157.14,91.39 157.14,95.76 v1(157.1,95.8)
  IN2 w0.254: v1(178.79,59.81) 178.58,60.02 177.25,60.02 176.36,59.13 173.19,59.13 172.36,58.3 172.36,53.6 171.61,52.85 v1(169.96,52.85)
  IN3 w0.254: v1(160.65,67.2) 160.65,67.35 161.29,67.99 167.53,67.99 167.8,68.26 v1(172.88,68.26)
  BOTTOM w0.203: v1(178.79,59.81) 178.66,59.69 177.43,59.69 177.23,59.48 PUZ01.35
  BOTTOM w0.254: PUG01.16 156.79,94.1 156.53,94.36 156.53,95.29 157.04,95.8 157.1,95.8 v1(157.1,95.8) ; v1(169.96,52.85) PUA01.3 ; v1(165.36,89.2) 165.43,89.2 165.72,88.91 PUI02.16 ; PUI01.16 160.92,65.3 160.65,65.57 v1(160.65,67.2)
EC_AGND: length 29.3
  TOP w0.203: UE1.112 34.4,75.81
  TOP w0.508: RE4.1 CE10.2 32.77,87.23 v1(33.19,87.65) 33.19,88.06 v2(32.76,88.49) 32.34,88.91 CE21.2 32.47,90.2 33.31,91.04 RE44.2 33.86,91.12 RE2.1 34.88,91.11 CE11.2 ; 34.4,75.81 32.76,75.81 32.55,76.02 31.56,76.02 31.2,75.66 CE31.2 30.21,75.37 CE26.2 30.02,75.36 v1(29.31,76.07)
  IN2 w0.508: v1(29.31,76.07) 29.31,79.56 32.46,82.71 32.46,84.22 31.94,84.74 31.94,86.4 v1(33.19,87.65)
EC_MUTE#: length 91.5
  TOP w0.112: v2(29.16,71.73) 29.36,71.93 29.36,72.07 29.63,72.34 RE29.2 29.46,72.7 v1(29.09,72.7) ; RA12.2 34.32,9.32 34.32,9.77 v1(34.01,10.09) 33.56,10.09 33.46,10.19 UA1.40
  IN1 w0.119: v1(29.09,72.7) 28.7,72.31 28.7,65.71 34.07,60.34 34.07,57.66 34.83,56.9 v1(34.83,52.13)
  IN3 w0.135: v1(32.53,40.89) 31.3,39.65 28.26,39.65 18.08,29.47 18.08,25.52 22.36,21.23 33.98,21.23 34.56,20.65 34.56,10.65 v1(34.01,10.09)
  BOTTOM w0.112: v1(32.53,40.89) 32.53,49.83 v1(34.83,52.13)
EDP_AUXN: length 100.5
  TOP w0.112: v1(216.75,54.21) 216.75,53.56 216.41,53.22 215.32,53.22 C17.1
  IN3 w0.135: v1(149,75.31) 148.83,75.15 148.83,75.13 148.72,75.02 148.72,74.71 148.86,74.58 161.88,74.58 163.52,72.94 173.09,72.94 174.29,71.74 177.04,71.74 183.94,64.85 193.33,64.85 194.02,64.16 198.36,64.16 199.97,62.55 201.85,62.55 205.9,58.5 212.25,58.5 212.48,58.73 215.17,58.73 216.57,57.34 216.57,54.4 v1(216.75,54.21)
  BOTTOM w0.076: 140.5,72.83 140.48,72.83 140.45,72.86 139.94,72.86 137.52,75.28 137.52,75.68 137.25,75.95 136.85,75.95 136.65,76.14 135.42,76.14 UC1.AH4
  BOTTOM w0.112: 140.5,72.83 142.17,72.83 142.77,72.23 143.63,72.23 143.65,72.22 144.18,72.22 144.19,72.23 v4(146,72.23) 148.48,72.23 149.28,73.03 149.28,74.05 149,74.34 v1(149,75.31)
EDP_AUXN_C: length 2.4
  TOP w0.112: v1(213.69,53.32) 213.78,53.41 214.07,53.41 C17.2
  BOTTOM w0.112: JEDP1.16 212.88,52.95 213.16,53.23 213.16,53.23 213.39,53.46 213.55,53.46 v1(213.69,53.32)
EDP_AUXP: length 100.5
  TOP w0.112: v1(216.17,54.21) 216.53,53.85 216.53,53.66 216.32,53.44 215.84,53.44 C19.1
  IN3 w0.135: v1(216.17,54.21) 216.17,54.23 216.33,54.39 216.33,57.24 215.07,58.49 212.58,58.49 212.35,58.26 205.8,58.26 201.75,62.31 199.87,62.31 198.26,63.92 193.92,63.92 193.23,64.61 183.84,64.61 176.94,71.5 174.19,71.5 172.99,72.7 163.42,72.7 161.78,74.34 148.76,74.34 148.48,74.61 148.48,75.24 v1(148.41,75.31)
  BOTTOM w0.076: 140.5,73.05 140.48,73.05 140.45,73.02 140.01,73.02 137.68,75.35 137.68,75.75 137.32,76.11 136.92,76.11 136.72,76.31 135.94,76.31 135.88,76.36 135.88,76.62 135.79,76.72 135.75,76.72 135.73,76.73 135.66,76.73 135.52,76.59 135.52,76.46 UC1.AH3
  BOTTOM w0.112: 140.5,73.05 142.26,73.05 142.86,72.45 v4(143.91,72.45) 145.72,72.45 145.73,72.46 146.26,72.46 146.27,72.45 148.39,72.45 149.06,73.12 149.06,73.96 148.78,74.25 148.78,74.72 148.66,74.84 148.3,74.84 148.19,74.95 148.19,75.14 148.36,75.31 v1(148.41,75.31)
EDP_AUXP_C: length 2.4
  TOP w0.112: v1(213.71,53.9) 213.9,53.71 214.06,53.71 214.33,53.99 C19.2
  BOTTOM w0.112: v1(213.71,53.9) 213.54,53.73 213.51,53.73 213.46,53.68 213.3,53.68 213.07,53.45 JEDP1.15
EDP_BKLT_CTRL: length 126.6
  TOP w0.112: D2.2 219.9,50.74 R11.2 220.16,50.48 v1(221.27,50.48) ; v1(168.69,42.35) 168.69,43.76 170.55,45.62 175.25,45.62 178.04,42.83 179.01,42.83 179.36,42.48 179.36,40.06 180.79,38.63 v2(181.44,38.63) 183.37,38.63 184.55,37.45 189.49,37.45 190.66,36.28 190.66,32.36 192.85,30.18 207.42,30.18 208.38,31.14 208.38,32.25 209.22,33.09 v1(209.22,33.78)
  IN2 w0.124: v1(221.27,50.48) 220.33,49.54 220.33,42.51 218.02,40.2 217.08,40.2 212.95,36.06 212.95,35.77 211.82,34.64 210.64,34.64 209.77,33.78 v1(209.22,33.78) ; v1(130.13,51.69) 130.95,50.87 134.37,50.87 135.82,49.42 138.7,49.42 141.58,46.54 142.24,46.54 146.11,42.67 149.65,42.67 150.66,41.67 158.2,41.67 160.72,44.19 166.28,44.19 167.61,42.86 168.18,42.86 v1(168.69,42.35)
  BOTTOM w0.089: UC1.CH11 130.15,51.73 v1(130.13,51.69)
EDP_COMP: length 4.4
  TOP w0.254: v1(133.42,73.54) 133.42,73.75 133.16,74.01 132.55,74.01 132.24,73.69 v2(132.06,73.69) 131.31,73.69 130.58,74.43 RC4.2
  BOTTOM w0.254: UC1.AM6 v1(133.42,73.54)
EDP_HPD: length 132.6
  TOP w0.112: R77.2 213.95,55.31 v1(213.95,55.53) ; v1(159.9,38.67) 159.9,37.74 158.45,36.29 155.01,36.29 v2(153.68,34.97) 152.71,33.99 147.06,33.99 145.17,35.87 142.96,35.87 142.15,36.69 142.15,41.69 139.62,44.22 135.43,44.22 134.6,43.4 134.52,43.4 134.39,43.26 v1(134.36,43.26)
  IN2 w0.124: v1(213.95,55.53) 214.92,54.56 214.92,50.91 216.28,49.55 216.28,48.9 215.92,48.54 215.92,47.33 215.63,47.05 214.61,47.05 214.09,46.53 214.09,46.52 213.76,46.19 213.41,46.19 212.82,46.78 212.82,47.75 211.55,49.02 208.12,49.02 207.23,48.13 207.23,47.49 206.66,46.92 206.66,43.66 207.13,43.19 207.13,42.67 206.71,42.25 205.5,42.25 204.54,41.28 201.38,41.28 200.61,40.52 196.83,40.52 195.74,39.43 194.39,39.43 193.46,40.36 193.46,43.32 189.65,47.13 181.69,47.13 177.73,43.17 177.73,40.01 176.18,38.46 172.51,38.46 171.57,37.52 167.32,37.52 167.31,37.51 167.22,37.51 165.38,39.35 160.68,39.35 159.99,38.67 v1(159.9,38.67)
  BOTTOM w0.076: v1(134.36,43.26) 134.2,43.42 134.09,43.42 133.75,43.76 133.75,45.76 132.64,46.87 132.64,47.1 132.58,47.16 132.58,47.44 133.18,48.04 133.18,48.08 133.22,48.2 133.22,48.44 133.18,48.55 133.18,48.73 133.18,48.74 133.18,48.81 133.05,48.94 133.05,49.16 132.8,49.41 UC1.CM7
  BOTTOM w0.112: JEDP1.12 213.36,54.95 v1(213.95,55.53)
EDP_TXN0: length 97.1
  TOP w0.112: C12.1 215.58,51.79 215.85,51.79 v1(216.06,52)
  IN3 w0.135: v1(146.83,73.75) 146.61,73.53 146.61,73.32 147.53,72.4 150.12,72.4 150.94,73.22 161.32,73.22 163.03,71.5 172.53,71.5 173.65,70.38 176.41,70.38 183.3,63.49 192.77,63.49 193.26,62.99 193.26,62.48 193.49,62.26 195.19,62.26 195.73,62.8 197.8,62.8 199.41,61.19 201.28,61.19 205.33,57.14 211.33,57.14 212.51,55.97 212.51,55.65 213.04,55.11 213.7,55.11 214.85,53.95 214.85,52 215.15,51.71 215.75,51.71 215.89,51.84 215.9,51.84 v1(216.06,52)
  BOTTOM w0.076: 140.5,74.38 140.48,74.38 140.45,74.36 140.37,74.36 137.28,77.44 136.52,77.44 136.44,77.41 136.33,77.37 136.11,77.37 136.02,77.4 135.76,77.4 135.53,77.3 135.51,77.28 135.42,77.25 135.11,77.25 UC1.AG4
  BOTTOM w0.112: v1(146.83,73.75) 146.8,73.79 146.8,74.26 146.58,74.48 142.02,74.48 141.93,74.38 140.5,74.38
EDP_TXN0_C: length 2.3
  TOP w0.112: v1(213.58,52) 213.79,51.79 214,51.79 C12.2
  BOTTOM w0.112: v1(213.58,52) 213.39,51.81 213.09,51.81 212.95,51.95 JEDP1.18
EDP_TXN1: length 100
  TOP w0.112: C14.1 215.58,49.89 216.63,49.89 v1(216.81,50.07)
  IN3 w0.135: v1(148.65,73.75) 148.49,73.59 148.49,73.58 148.3,73.4 148.3,73.22 148.44,73.08 149.84,73.08 150.66,73.9 161.6,73.9 163.32,72.18 172.89,72.18 174.01,71.06 176.69,71.06 183.58,64.17 193.05,64.17 193.73,63.48 198.08,63.48 199.69,61.87 201.56,61.87 205.62,57.82 211.61,57.82 213.22,56.21 215.07,56.21 215.35,55.94 215.35,54.42 216.84,52.93 216.84,51.26 216.19,50.6 216.19,49.99 216.32,49.86 216.6,49.86 v1(216.81,50.07)
  BOTTOM w0.076: 140.5,73.53 140.48,73.53 140.45,73.55 140.25,73.55 137.27,76.54 136.22,76.54 136.04,76.72 136.04,76.83 UC1.AG2
  BOTTOM w0.112: v1(148.65,73.75) 148.6,73.7 148.6,73.25 148.33,72.98 143.03,72.98 142.48,73.53 140.5,73.53
EDP_TXN1_C: length 2.2
  TOP w0.112: v1(213.65,50.29) 213.79,50.14 214.25,50.14 C14.2
  BOTTOM w0.112: JEDP1.21 212.99,50.45 213.27,50.17 213.53,50.17 v1(213.65,50.29)
EDP_TXP0: length 97.1
  TOP w0.112: C13.1 215.58,51.57 215.9,51.57 v1(216.06,51.42)
  IN3 w0.135: v1(216.06,51.42) 216.01,51.47 215.05,51.47 214.61,51.9 214.61,53.85 213.6,54.87 212.94,54.87 212.26,55.55 212.26,55.87 211.23,56.9 205.23,56.9 201.18,60.95 199.31,60.95 197.7,62.56 195.83,62.56 195.29,62.02 193.39,62.02 193.02,62.38 193.02,62.89 192.67,63.24 183.2,63.24 176.31,70.14 173.55,70.14 172.43,71.26 162.93,71.26 161.22,72.98 151.04,72.98 150.22,72.16 147.43,72.16 146.36,73.22 146.36,73.64 v1(146.25,73.75)
  BOTTOM w0.076: 140.5,74.16 140.48,74.16 140.45,74.19 140.3,74.19 137.22,77.27 136.55,77.27 136.5,77.25 136.36,77.2 136.08,77.2 135.99,77.24 135.8,77.24 135.62,77.16 135.6,77.13 135.57,77.12 135.57,76.87 135.37,76.67 135.24,76.67 135.14,76.77 135.14,76.86 UC1.AG3
  BOTTOM w0.112: 140.5,74.16 142.02,74.16 142.11,74.25 146.49,74.25 146.57,74.17 146.57,74.08 v1(146.25,73.75)
EDP_TXP0_C: length 2.3
  TOP w0.112: C13.2 214,51.57 213.74,51.57 v1(213.58,51.42)
  BOTTOM w0.112: JEDP1.19 212.97,51.45 213.11,51.59 213.41,51.59 v1(213.58,51.42)
EDP_TXP1: length 100
  TOP w0.112: v1(216.81,49.49) 216.63,49.67 215.58,49.67 C15.1
  IN3 w0.135: v1(148.06,73.75) 148.06,73.12 148.34,72.84 149.94,72.84 150.76,73.66 161.5,73.66 163.22,71.94 172.79,71.94 173.91,70.82 176.59,70.82 183.48,63.92 192.95,63.92 193.63,63.24 197.98,63.24 199.59,61.63 201.46,61.63 205.52,57.58 211.51,57.58 213.12,55.97 214.97,55.97 215.11,55.84 215.11,54.32 216.6,52.83 216.6,51.36 215.95,50.71 215.95,49.89 216.22,49.62 216.68,49.62 v1(216.81,49.49)
  BOTTOM w0.076: UC1.AG1 136.52,77 136.28,77 136.21,76.92 136.21,76.79 136.29,76.7 137.34,76.7 140.32,73.72 140.46,73.72 140.49,73.75 140.5,73.75
  BOTTOM w0.112: 140.5,73.75 142.58,73.75 143.12,73.2 148.24,73.2 148.38,73.34 148.38,73.44 v1(148.06,73.75)
EDP_TXP1_C: length 2.2
  TOP w0.112: v1(213.65,49.7) 213.68,49.73 213.94,49.73 C15.2
  BOTTOM w0.112: JEDP1.22 213.4,49.95 v1(213.65,49.7)
EDP_VDD_EN: length 156.8
  TOP w0.112: v2(218.32,63.5) D4.2 v1(219.44,61.86)
  IN2 w0.124: v1(167.19,28.51) 167.57,28.89 171.15,28.89 172.48,27.56 174.34,27.56 174.72,27.94 175.9,27.94 180.31,32.34 189.15,32.34 189.54,32.73 v1(190.08,32.73)
  IN3 w0.089: v1(130.12,52.35) 130.12,52.3 129.7,51.87 129.7,49.97 130.43,49.24
  IN3 w0.135: v1(219.44,61.86) 220.05,61.86 223.81,58.1 223.81,36.63 223.87,36.57 v1(223.87,34.86) ; v1(167.19,28.51) 163.99,28.51 163.4,29.1 159.25,29.1 158.43,28.28 148.87,28.28 143.54,33.61 143.54,34.39 141.65,36.28 140.58,36.28 140.34,36.04 135.35,36.04 134.65,36.74 133.79,36.74 132.63,37.9 132.63,40.89 132.53,41 132.53,44.16 133.4,45.03 133.4,47.5 132.26,48.65 131.02,48.65 130.43,49.24
  BOTTOM w0.089: UC1.CG11 v1(130.12,52.35)
  BOTTOM w0.112: v1(190.08,32.73) 190.08,30.96 190.86,30.18 213.88,30.18 214.79,29.27 216.19,29.27 217.46,28 220.33,28 223.87,31.54 v1(223.87,34.86)
EMMC_RCOMP: length 2.7
  TOP w0.254: RC64.1 125.94,49.54 v2(126.25,49.85) 126.81,50.41 v1(127,50.41)
  BOTTOM w0.254: UC1.CK15 127.5,50.55 v1(127,50.41)
EN_0.6VSP: length 2.9
  TOP w0.203: PRM09.2 33.64,30.92 PCM16.1 34.49,29.21 PUM01.7
EN_1.2V: length 2.7
  TOP w0.203: PRM08.2 33.63,28.37 PCM15.1 34.08,29.13 34.4,28.81 PUM01.8
EN_1.05V: length 5.3
  TOP w0.254: v1(162.85,46.67) 163.56,46.67 v2(163.9,46.33) 164.44,45.79 PCH09.1 PRH02.1 PRH01.2
  BOTTOM w0.254: PUH01.6 161.92,46.63 162.1,46.81 162.7,46.81 v1(162.85,46.67)
EN_1.8V: length 5.2
  BOTTOM w0.112: PR1801.2 v2(201.95,59.74)
  BOTTOM w0.254: PU1801.5 200.99,55.89 200.81,56.07 200.81,56.82 201.08,57.08 PC1805.1 PR1802.1 201.89,58.67 PR1801.2
EN_2.5V: length 2.7
  TOP w0.254: PR2501.1 PC2503.1 73.11,111.69 PU2501.2
EN_3V: length 51.8
  TOP w0.112: v1(19.44,45.45) v3(19.44,46.13)
  IN1 w0.254: v1(19.44,45.45) 19.44,44.48 18.89,43.94 18.07,43.94 17.81,44.19 17.81,45.84 18.2,46.22 18.2,50.34 18.8,50.95 18.8,56.73 21.64,59.56 21.64,62.44 23.64,64.43 23.64,74.73 19.64,78.72 19.64,83.75 19.8,83.9 19.8,85.34 v1(19.74,85.39)
  BOTTOM w0.254: PR502.1 20.32,86 19.74,85.43 v1(19.74,85.39) ; PU301.12 v1(19.44,45.45)
EN_5V: length 4.4
  BOTTOM w0.112: v2(28.32,92.77) 27.85,93.24 27.85,93.47 27.34,93.98 PC2506.1
  BOTTOM w0.203: PC2506.1 27.3,94.08 PR503.1 26.49,94.7 26.01,95.18 PU501.12
EN_+1.35VGPU: length 5.4
  BOTTOM w0.112: PCW09.1 v2(137.46,111.34)
  BOTTOM w0.254: PCW09.1 PRW02.1 PRW01.2 140.06,111.04 141.55,109.56 PUW01.6
EN_CPU: length 2
  BOTTOM w0.203: PUZ01.37 178.82,58.1 179.36,58.63 179.36,58.9 179.76,59.3 PRZ22.1
ENABLE_VGA: length 2.3
  TOP w0.203: PRV15.2 70.29,128.7 v2(70.52,128.7) PUV01.8
ENLDO_3V5V: length 65.3
  TOP w0.112: v1(18.41,45.09) 18.25,45.09 v2(17.97,44.8)
  TOP w0.254: PC317.1 19.01,46.46 19.01,45.68 v1(18.41,45.09)
  IN1 w0.254: v1(27.1,94.97) 27.1,93.29 26.65,92.85 26.65,90.49 21.66,85.5 21.66,82.77 21.24,82.34 20.49,82.34 20,81.85 20,78.87 23.99,74.87 23.99,64.28 22,62.29 22,59.42 19.16,56.58 19.16,50.8 18.56,50.2 18.56,46.01 18.39,45.84 18.39,45.12 v1(18.41,45.09)
  BOTTOM w0.203: PU501.11 26.46,95.17 26.66,94.97 v1(27.1,94.97)
  BOTTOM w0.254: v1(18.41,45.09) 18.41,45.37 18.11,45.68 18.11,46.04 PR302.1 18.99,46.09 PR303.1 19.01,45.78 18.94,45.71 18.94,45.08 18.99,45.04 PU301.11
ESPI_CLK: length 13
  TOP w0.112: RC26.1 107.69,53.14 111.07,56.53 114.01,56.53 114.55,57.06 v2(114.85,57.06) v1(116.69,57.06)
  BOTTOM w0.102: UC1.BV32 116.69,57.32 v1(116.69,57.06)
ESPI_CLK_R: length 146.5
  TOP w0.102: 52.77,78.67 52.65,78.8 52.36,78.8 52.15,79.01 UE1.57
  TOP w0.112: 52.77,78.67 52.89,78.67 v1(52.89,78.67) 53.46,79.23 53.46,79.38 53.93,79.86 RE39.2 ; v1(100.33,45.93) 100.41,46.01 100.41,48.15 v2(102.49,50.23) 103.06,50.81 103.06,52.32 103.89,53.14 CC3.1 RC26.2
  IN3 w0.135: v1(52.89,78.67) 52.96,78.67 53.16,78.46 53.16,73.36 53.76,72.76 53.76,69.61 54.37,69 54.37,66.09 55.21,65.24 55.21,63.15 55.08,63.02 54.51,63.02 54.37,62.88 54.37,62.62 54.51,62.48 55.08,62.48 55.21,62.35 55.21,62.08 55.08,61.94 54.51,61.94 54.37,61.81 54.37,61.54 54.51,61.4 55.08,61.4 55.21,61.27 55.21,61 55.08,60.87 54.51,60.87 54.37,60.73 54.37,60.46 54.51,60.33 55.08,60.33 55.21,60.19 55.21,59.78 55.08,59.64 53.8,59.64 53.66,59.51 53.66,59.24 53.8,59.1 55.08,59.1 55.21,58.97 55.21,58.7 55.08,58.56 52.74,58.56 52.6,58.43 52.6,58.16 52.74,58.03 54.38,58.03 54.52,57.89 54.52,57.59 54.38,57.46 53.37,57.46 52.3,56.39 52.11,56.39 51.43,57.08 51.24,57.08 51.05,56.89 51.05,56.7 51.73,56.01 51.73,55.82 51.09,55.18 51.09,43.14 52.84,41.4 54.01,41.4 55.61,39.79 57.57,39.79 58.72,38.64 59.49,38.64 61.18,36.95 71.83,36.95 72.34,36.44 77.34,36.44 81.22,40.33 83.4,42.5 85.82,42.5 88.93,45.61 91.26,45.61 91.78,45.1 93.33,45.1 93.42,45.01 97.56,45.01 98.4,45.84 100.24,45.84 v1(100.33,45.93)
  BOTTOM w0.102: JESPI1.10 45.88,98.87
  BOTTOM w0.112: 45.88,98.87 46,98.87 46.26,98.61 46.26,97.34 48.04,95.56 48.04,90.42 53.68,84.78 53.68,79.42 52.93,78.67 v1(52.89,78.67)
ESPI_CS#: length 143.8
  TOP w0.112: UE1.58 52.2,79.41 52.56,79.76 53.02,79.76 53.38,80.12 53.38,80.76 53.25,80.9 53.25,81.08 v1(53.13,81.2)
  IN3 w0.135: v1(53.13,81.2) 53.25,81.08 53.25,80.9 53.94,80.2 53.94,73.68 55.46,72.16 55.46,69.01 55.99,68.48 55.99,57.86 51.98,53.84 51.98,45.91 53.56,44.32 53.56,43.05 55.98,40.64 57.88,40.64 58.96,39.56 59.85,39.56 60.74,38.67 63.15,38.67 63.81,38.01 77.59,38.01 77.81,38.01 83.08,43.28 85.5,43.28 89.24,47.02 89.56,46.7 95.29,46.7 95.35,46.64 100.89,46.64 101.88,45.65 107.98,45.65 110.06,47.73 110.06,48.43 110.84,49.21 110.84,50.98 112.77,52.91 114.03,52.91 116.8,55.68 118.82,55.68 v1(119.24,55.27)
  BOTTOM w0.089: UC1.CA28 119.46,55.64 v1(119.24,55.27)
  BOTTOM w0.112: v1(53.13,81.2) 52.99,81.34 52.74,81.34 52.49,81.59 52.49,84.39 47.51,89.36 47.51,95.28 45.42,97.37 JESPI1.7
ESPI_IO0: length 16.4
  TOP w0.112: RC192.1 v2(106.96,50.1) 107.66,50.1 109.3,51.73 109.3,53.04 111.57,55.32 114.52,55.32 114.67,55.47 116.9,55.47 117.06,55.63 118.24,55.63 v1(118.6,55.27)
  BOTTOM w0.089: UC1.CA29 v1(118.6,55.27)
ESPI_IO0_R: length 149.9
  TOP w0.112: UE1.59 50.39,79.81 49.38,78.8 47.78,78.8 47.56,79.03 v1(47.56,79.68) ; RC192.2 104.06,50.1 101.62,47.65 101.62,38.22 v2(101.36,37.96) v1(100.89,37.49)
  IN3 w0.135: v1(47.56,79.68) 47.56,79.58 46.64,78.66 46.64,62.6 45.94,61.91 45.94,55.68 42.9,52.64 42.9,47.56 43.85,46.6 43.85,40.7 50.03,34.51 54.47,34.51 55.16,33.82 56.55,33.82 58.04,32.33 58.66,32.33 61.53,29.46 68.3,29.46 69,28.76 86.5,28.76 87.91,30.17 88.95,30.17 91.35,32.57 91.35,35.42 92.94,37.02 98.31,37.02 98.76,36.57 99.97,36.57 v1(100.89,37.49)
  BOTTOM w0.112: JESPI1.3 45.49,95.37 46.56,94.3 46.56,87.52 48.04,86.04 48.04,84.95 48.78,84.21 50.2,84.21 50.67,83.74 50.67,83.1 50.15,82.58 49.48,82.58 48.29,81.39 48.29,80.42 v1(47.56,79.68)
ESPI_IO1: length 16.3
  TOP w0.112: v1(118.6,56.14) 118.4,55.94 116.31,55.94 116.08,55.71 114.57,55.71 114.42,55.56 111.47,55.56 108.85,52.93 v2(108.85,52.27) 108.85,51.62 108.05,50.82 105.94,50.82 RC193.1
  BOTTOM w0.089: UC1.BY29 118.87,56.61 v1(118.6,56.14)
ESPI_IO1_R: length 151.6
  TOP w0.112: RC193.2 104.49,50.86 101.38,47.75 101.38,38.56 v1(100.31,37.49) ; v2(52.89,80.07) 52.75,80.21 UE1.60 50.4,80.21 49.38,79.19 v1(47.94,79.19)
  IN3 w0.135: v1(47.94,79.19) 47.96,79.17 47.96,78.98 46.9,77.91 46.9,62.42 46.26,61.78 46.26,55.56 43.21,52.51 43.21,47.68 44.17,46.73 44.17,40.75 50.14,34.77 54.58,34.77 55.27,34.08 56.66,34.08 58.15,32.59 58.77,32.59 61.59,29.78 69.31,29.78 69.82,29.27 86.63,29.27 87.8,30.43 88.83,30.43 90.96,32.56 90.96,35.41 92.84,37.28 98.42,37.28 98.87,36.83 99.65,36.83 v1(100.31,37.49)
  BOTTOM w0.112: v1(47.94,79.19) 47.94,79.73 49.33,81.11 49.33,82.09 49.58,82.34 50.82,82.34 51.38,82.9 51.38,83.97 50.9,84.45 48.88,84.45 48.28,85.05 48.28,86.13 46.8,87.62 46.8,94.91 45.84,95.87 JESPI1.4
ESPI_IO2: length 16.7
  TOP w0.112: RC194.1 106.28,52 v2(107.44,52) 107.58,52 111.37,55.8 114.32,55.8 114.47,55.95 115.98,55.95 116.22,56.19 117.92,56.19 118.1,56.37 118.1,56.37 118.3,56.57 119.48,56.57 v1(119.87,56.18)
  BOTTOM w0.089: v1(119.87,56.18) UC1.BY27
ESPI_IO2_R: length 150
  TOP w0.112: RC194.2 104.56,51.62 104.43,51.49 104.43,51.14 101.14,47.85 101.14,43.25 101.03,43.14 v2(101.03,41.93) 101.03,40.93 100.59,40.49 100.59,38.35 v1(99.72,37.49) ; v1(48.36,79.59) 48.59,79.81 49.41,79.81 50.2,80.61 UE1.61
  IN3 w0.135: v1(48.36,79.59) 48.34,79.57 48.34,78.75 47.16,77.57 47.16,62.23 46.58,61.65 46.58,55.43 43.53,52.38 43.53,47.81 44.48,46.86 44.48,40.8 50.25,35.03 54.69,35.03 55.37,34.35 56.77,34.35 58.26,32.85 58.88,32.85 61.69,30.04 69.42,30.04 69.93,29.53 86.53,29.53 87.69,30.69 88.72,30.69 90.7,32.67 90.7,35.51 92.73,37.54 98.53,37.54 98.98,37.09 99.34,37.09 99.72,37.48 v1(99.72,37.49)
  BOTTOM w0.112: v1(48.36,79.59) 49.56,80.79 49.56,81.99 49.68,82.1 50.96,82.1 51.62,82.76 51.62,83.98 51.62,84.06 51,84.69 48.98,84.69 48.52,85.15 48.52,86.23 47.04,87.72 47.04,95.08 45.74,96.37 JESPI1.5
ESPI_IO3: length 16.5
  TOP w0.112: RC195.1 106.17,52.65 107.89,52.65 111.28,56.04 114.22,56.04 114.37,56.19 115.88,56.19 116.25,56.56 v2(117,56.56) 117.95,56.56 118.58,57.19 119.78,57.19 v1(119.87,57.09)
  BOTTOM w0.076: UC1.BV27 v1(119.87,57.09)
ESPI_IO3_R: length 136.6
  TOP w0.112: v1(100.16,44.52) 100.35,44.52 100.9,45.08 100.9,47.95 103.55,50.6 v2(103.55,51.42) 103.55,52.12 103.82,52.38 RC195.2 ; v1(52.61,80.84) 52.45,81.01 UE1.62 50.05,81.01 v1(50.03,81.03)
  IN3 w0.135: v1(100.16,44.52) 100.33,44.52 101,45.19 101,46.16 100.8,46.36 98.18,46.36 97.66,45.84 97.07,45.84 96.53,46.38 95.25,46.38 95.19,46.44 89.03,46.44 85.61,43.02 83.19,43.02 77.88,37.71 63.92,37.71 63.72,37.52 61.38,37.52 59.72,39.17 58.96,39.17 57.82,40.32 55.85,40.32 54.2,41.97 52.99,41.97 51.66,43.3 51.66,53.91 55.73,57.98 55.73,65.97 55.6,66.1 55.09,66.1 54.95,66.24 54.95,66.5 55.09,66.64 55.6,66.64 55.73,66.77 55.73,67.2 55.6,67.33 55.02,67.33 54.89,67.47 54.89,67.74 55.02,67.87 55.6,67.87 55.73,68.01 55.73,68.33 55.6,68.46 55.2,68.46 55.05,68.62 55.05,69.05 54.28,69.83 54.28,72.97 53.68,73.57 53.68,79.38 53.54,79.51 52.93,79.51 52.61,79.83 v1(52.61,80.84)
  BOTTOM w0.112: JESPI1.6 45.59,96.87 47.28,95.18 47.28,87.82 48.76,86.33 48.76,85.24 49.08,84.93 51.18,84.93 51.86,84.25 51.86,82.49 50.39,81.03 v1(50.03,81.03)
ESPI_RST#: length 122.3
  TOP w0.112: RC205.2 120.53,54.61 v1(119.87,55.27) ; v1(54.67,76.6) 54.51,76.6 54.32,76.41 53.42,76.41 v2(52.93,76.91) 52.7,76.91 52.2,77.41 UE1.53
  IN3 w0.135: v1(119.87,55.27) 120.3,55.7 120.3,56.45 120.17,56.58 118.15,56.58 117.52,55.95 116.69,55.95 113.92,53.18 112.66,53.18 110.58,51.09 110.58,49.32 109.8,48.53 109.8,47.84 107.87,45.91 101.99,45.91 100.99,46.91 96.65,46.91 96.59,46.97 93.46,46.97 92.85,47.57 89.42,47.57 85.39,43.54 82.97,43.54 77.7,38.27 63.93,38.27 63.22,38.98 60.87,38.98 59.98,39.87 59.09,39.87 58.01,40.95 56.1,40.95 53.88,43.18 53.88,44.45 52.29,46.03 52.29,53.72 56.3,57.72 56.3,68.58 56.1,68.77 56.08,68.77 55.72,69.12 55.72,75.92 55.04,76.6 v1(54.67,76.6)
  BOTTOM w0.089: UC1.CA27 v1(119.87,55.27)
EXT_PWR_GATE#: length 4.2
  BOTTOM w0.102: TP24.1 110.97,52.45 113.08,54.55 UC1.CC37
FAN1_PWM: length 202
  TOP w0.112: RE17.1 55.5,74.8 v1(55.13,74.8) 54.63,74.8 54.56,74.72 52.95,74.72 52.66,75.01 UE1.47
  IN2 w0.124: v1(179.36,71.17) 172.94,71.17 168.07,76.04 168.07,88.17 167.56,88.67 167.56,94.39 157.11,104.85 144.27,104.85 143.63,104.21 138.95,104.21 134.79,108.37 131.14,108.37 130.1,107.32 126.45,107.32 122.59,111.18 114.14,111.18 113.71,110.75 87.09,110.75 86.55,111.28 76.68,111.28 75.61,112.36 73.73,112.36 73.32,111.94 63.46,111.94 63.04,112.36 61.8,112.36 61.62,112.18 56.6,112.18 52.2,107.79 52.2,93.94 53.12,93.02 53.12,82.74 51.98,81.59 51.98,80.58 52.1,80.45 52.99,80.45 55.28,78.16 55.28,74.92 55.15,74.8 v1(55.13,74.8)
  BOTTOM w0.112: v1(179.36,71.17) 179.37,71.17 179.8,70.73 180.07,70.73 181.03,71.7 JFAN1.2
FAN1_TACH: length 203.2
  TOP w0.112: v1(55.06,70.85) 54.59,71.32 53.71,71.32 53.52,71.52 CE28.1 53.52,72.68 RE16.1 52.86,72.69 52.38,72.21 UE1.40
  IN2 w0.124: v1(179.94,71.16) 179.56,70.78 179.2,70.78 179.03,70.94 171.86,70.94 166.71,76.09 166.71,83.32 167.21,83.81 167.21,86.34 167.85,86.98 167.85,88.07 167.34,88.58 167.34,94.3 157.01,104.62 144.36,104.62 143.73,103.99 138.85,103.99 135.38,107.46 130.56,107.46 130.19,107.09 126.04,107.09 125.44,107.69 121.64,107.69 119.3,110.03 114.28,110.03 113.79,110.52 87,110.52 86.46,111.06 76.59,111.06 75.51,112.13 73.83,112.13 73.41,111.72 63.36,111.72 62.95,112.13 61.89,112.13 61.72,111.96 58.21,111.96 56.8,110.55 56.8,107.27 56.51,106.98 56.51,106.15 55.83,105.47 v1(55.79,105.47)
  BOTTOM w0.102: 56.17,83.62 56.17,82.86 55.68,82.38
  BOTTOM w0.112: v1(179.94,71.16) 180.25,71.46 180.25,72.26 180.69,72.7 JFAN1.3 ; v1(55.79,105.47) 55.5,105.18 55.5,92.51 55.5,84.65 56.17,83.98 56.17,83.62 ; v1(55.06,70.85) 55.53,71.32 55.53,82.23 55.68,82.38
FB_1.2V: length 6.5
  TOP w0.112: PRM10.1 34.04,33.6 v2(34.53,34.08)
  TOP w0.203: PCM17.1 34.2,32.09 34.2,31.23 34.12,31.15 34.12,30.23 34.74,29.61 PUM01.6 ; PCM17.1 33.23,32.25 PRM11.1 ; PCM17.1 PRM10.1
FB_1.05V: length 5.1
  BOTTOM w0.112: PRH09.1 v2(167.52,43.54)
  BOTTOM w0.254: PRH09.1 PRH08.1 PRH12.2 165.01,43.59 163.98,44.62 PUH01.10
FB_1.8V: length 4.7
  BOTTOM w0.112: PR1807.2 206.28,57.01 v2(206.43,57.16)
  BOTTOM w0.254: PR1805.1 PC1807.2 PR1807.2 205.33,56.13 205.09,55.89 PU1801.6
FB_2PH_CPU: length 7.8
  TOP w0.112: v2(179.37,50.57) 179.02,50.22 PRZ24.1
  TOP w0.254: v1(178.91,51.27) 178.72,51.07 PCZ15.1 178.3,50.3 PRZ24.1
  BOTTOM w0.203: PUZ01.3 176.83,52.29 177.56,51.56 178.62,51.56 v1(178.91,51.27) 178.28,50.64 PRZ21.2 178.28,49.57 PCZ13.2
FB_3V: length 5.7
  BOTTOM w0.112: PR307.2 20.66,46.18 20.21,46.63 20.21,47.4 v2(19.66,47.96)
  BOTTOM w0.254: PU301.13 19.89,45.2 19.97,45.28 19.97,45.65 19.78,45.85 PR308.1 PR307.2 21.48,46.08 PC315.1
FB_3V_R: length 1.9
  BOTTOM w0.112: PR306.1 v2(21.52,48.92)
  BOTTOM w0.254: PC315.2 21.51,47.85 PR306.1
FB_5V: length 5.8
  BOTTOM w0.112: PR510.2 24.72,94.04 24,94.76 22.98,94.76 v2(22.77,94.55)
  BOTTOM w0.203: PC517.1 24.8,93.96 PR510.2 25.13,94.04 25.14,94.05 25.68,94.05 PR511.1 25.69,95.13 25.56,95.26 PU501.13
FB_5V_R: length 1.9
  BOTTOM w0.112: PR509.1 v2(22.89,92.31)
  BOTTOM w0.254: PC517.2 PR509.1
FB__+1.35VGPU: length 6.1
  BOTTOM w0.254: PRW13.2 144,113.41 143.07,113.09 142.6,112.62 PRW10.1 142.69,112.25 PRW09.1 143.35,111.38 PUW01.10
FB_GND: length 2.5
  TOP w0.381: RV158.1 116.31,138.04 v2(116.97,137.38) 117.26,137.09 v1(117.26,136.91)
  BOTTOM w0.305: UV1.AD20 117.26,136.88 v1(117.26,136.91)
FB_VDDC: length 3.3
  TOP w0.102: v2(117.8,136.29) 117.89,136.38 v1(117.89,136.98)
  TOP w0.381: v1(117.89,136.98) 117.89,137.2 117.21,137.88 RV159.1
  BOTTOM w0.305: UV1.AC20 118.44,136.4 117.89,136.95 v1(117.89,136.98)
FB_VDDCI: length 2.4
  BOTTOM w0.102: 121.33,122.19 UV1.W1
  BOTTOM w0.112: 121.33,122.19 121.07,121.92 TP73.1
FFS_INT1: length 73.9
  TOP w0.112: v1(168.03,27.18) 168.03,27.34 v2(168.96,28.27) 169.58,28.89 169.58,29.14 169.84,29.4 US2.12
  IN3 w0.135: v1(127.13,32.35) 127.22,32.26 143.1,32.26 148.5,26.86 158.83,26.86 160.56,28.59 162.94,28.59 164.66,26.86 167.71,26.86 v1(168.03,27.18)
  BOTTOM w0.076: RC27.2 121.07,44.66 120.6,44.19 120.6,42.5 ; UC1.CG22 123.37,52.29 123.09,52.01 123.09,51.81 122.61,51.33 122.61,50.12 122.42,49.93 122.42,49.26 122.31,48.98 122.31,47.56 122.34,47.54
  BOTTOM w0.112: v1(127.13,32.35) 126.77,32.71 125.12,32.71 124.24,33.59 124.24,35.6 121.68,38.16 120.94,38.16 120.56,38.53 120.56,41.16 120.6,41.19 120.6,42.5 ; 122.34,47.54 122.34,46.26 122.02,45.94 122.02,45.47 121.78,45.24 121.18,45.24 121.07,45.13 RC27.2
FFS_INT2: length 64.7
  TOP w0.112: v1(130.57,42.42) 131.14,41.86 131.14,40.1 131.67,39.57 131.67,38.65 133.64,36.68 133.64,36.24 134.85,35.03 144.83,35.03 146.91,32.94 153.06,32.94 155.47,35.35 159.63,35.35 v2(161.1,33.87) 161.45,33.52 161.45,31.11 v1(161.77,30.79) ; US2.11 169.45,29.9 169.33,29.78 RS29.2 168.73,29.99 168.31,30.41 167.04,30.41 166.81,30.65 166.81,31.15 166.4,31.55 QS1.2 166.22,31.55 165.59,32.19 163.95,32.19 v1(163.42,31.66)
  IN1 w0.119: v1(161.77,30.79) 161.77,30.8 162.56,30.8 v1(163.42,31.66)
  IN3 w0.089: 128.51,51.15 v1(129.04,51.68)
  IN3 w0.102: 128.18,49.27 128.18,49.46 128.51,49.79 128.51,51.15
  IN3 w0.135: v1(130.57,42.42) 130.57,42.45 129.92,43.1 129.92,45.31 129.68,45.54 129.68,47.6 129.21,48.07 128.75,48.07 128.16,48.66 128.16,49.26 128.18,49.27
  BOTTOM w0.089: UC1.CH12 129.59,51.87 v1(129.04,51.68)
  BOTTOM w0.112: v1(130.57,42.42) 130.52,42.42 130.08,41.99 RC109.2
FFS_INT2_Q: length 33.3
  TOP w0.112: QS1.3 166.28,30.84 RS31.2 164.5,30.84 v2(164.21,30.55) 164.12,30.46 v1(164.12,30.04)
  IN1 w0.119: v1(164.12,30.04) 164.36,29.79 171.88,29.79 173.11,28.56 175.63,28.56 177.84,30.77 177.84,31.08 180.33,33.57 186.89,33.57 187.13,33.82 187.13,34.96 186.05,36.04 v1(186.05,36.69)
  BOTTOM w0.112: v1(186.05,36.69) 186.2,36.53 JHDD1.9
FPR_SCAN#: length 265.6
  TOP w0.112: v1(221.19,42.98) 221.19,44.43 v2(220.24,45.38) 220,45.62 217.29,45.62 217.11,45.44 v1(217.11,45.08) ; v1(38.01,72.64) 38.36,73 49.22,73 49.33,73.11 50.43,73.11 50.53,73.01 UE1.42
  IN2 w0.124: v1(38.01,72.64) 38.01,71.43 36.86,70.29 36.86,64.92 37.32,64.46 38.84,64.46 39.45,63.86 40.23,63.86 41.86,62.22 42.66,62.22 46.28,58.6 46.28,54.25 45.56,53.52 45.56,48.09 45.95,47.7 45.95,39.27 50.68,34.53 54.97,34.53 60.1,29.39 60.57,29.39 61.81,28.16 65.45,28.16 66.06,28.77 68.25,28.77 68.42,28.6 70.99,28.6 71.57,29.18 84.96,29.18 86.05,28.09 88.77,28.09 89.95,29.28 92.99,29.28 94.14,28.13 95.3,28.13 95.42,28.26 95.42,29.66 97.28,31.52 103.91,31.52 104.52,32.13 106.02,32.13 106.4,31.74 115.24,31.74 115.64,32.14 118.2,32.14 118.72,31.61 119.85,31.61 120.68,32.44 121.7,32.44 122.53,31.61 124,31.61 125.16,32.77 127.7,32.77 129.09,31.39 131.39,31.39 134.45,34.45 145.66,34.45 146.64,33.47 163.62,33.47 164.35,34.2 172.03,34.2 173.45,35.62 196.13,35.62 197.62,37.11 205.36,37.11 207.47,39.21 211.64,39.21 214.49,42.06 214.68,42.06 216.64,42.06 217.2,42.63 217.2,44.98 v1(217.11,45.08)
  IN3 w0.135: v1(221.19,42.98) 221.19,40.9 222.09,40 222.09,38.41 222.96,37.55 222.96,35.71 v1(223.43,35.24)
  BOTTOM w0.112: JFP1.2 220.52,31.52 221.7,32.7 R6.2 222.16,32.74 EU6.3 222.99,35.24 v1(223.43,35.24)
FSET_CHG: length 3.7
  TOP w0.112: v2(203.83,42.31) 203.83,43.25 PRB38.1
  TOP w0.203: v1(205.27,42.6) 204.45,43.42 PRB38.1
  BOTTOM w0.203: v1(205.27,42.6) 205.23,42.64 PUB01.3
GPD7: length 3.5
  BOTTOM w0.102: RC58.2 112.67,57.84 112.9,57.62 113.49,57.62 113.69,57.82 113.88,57.82 114.05,57.99 114.62,57.99 UC1.BV35
GPIO19_CTF: length 5
  BOTTOM w0.102: 127.11,122.19 127.11,122.77 UV1.M2
  BOTTOM w0.112: 127.11,122.19 127.11,121.29 126.58,120.77 126.58,119.9 RV151.1 127.89,119.52 v2(127.99,119.41)
GPIO28: length 8.4
  BOTTOM w0.102: UV1.R5 125.33,123.81 125.33,122.19
  BOTTOM w0.112: v2(122.72,117.65) 122.72,119.13 123.11,119.52 RV22.2 123.29,119.39 RV21.2 123.92,120.45 125.33,121.85 125.33,122.19
GPP_A11: length 8.7
  BOTTOM w0.076: UC1.CA32 116.75,55.72 116.55,55.52 114.67,55.52 114.54,55.55 114.4,55.63 114.14,55.63 114.11,55.62 114.11,55.62 113.89,55.53 112.78,55.53 112.21,54.95 110.07,54.95 109.36,54.24 TP25.1
GPP_B23: length 3.1
  TOP w0.112: v1(116.47,54.63) 116.49,54.6 RC46.2 117.47,53.98 117.89,54.4 v2(117.89,54.64)
  BOTTOM w0.076: UC1.CC34 115.94,54.63 v1(116.47,54.63)
GPP_C2: length 7
  TOP w0.112: v1(127,51.03) 126.83,51.03 v2(124.84,49.04) 124.48,48.68 124.48,47.52 RC38.2
  BOTTOM w0.102: UC1.CJ15 v1(127,51.03)
GPP_C5: length 8.4
  TOP w0.112: v1(126.99,52.25) 126.61,51.87 126.61,51.11 125.19,49.69 125.05,49.69 123.94,48.57 v2(123.94,47.98) 124.19,47.72 124.19,47.41 125,46.6 RC44.2
  BOTTOM w0.102: UC1.CG15 127.5,52.49 v1(126.99,52.25)
GPP_H21: length 9.6
  TOP w0.112: v1(120.79,53.08) 120.79,52.85 120.38,52.45 120.38,52.11 120.84,51.65 v2(120.84,50.94) 120.84,50.62 120.68,50.46 120.68,46.58 120.18,46.07 120.18,45.35 RC62.2
  BOTTOM w0.076: UC1.CF25 v1(120.79,53.08)
GPP_H23: length 5.8
  BOTTOM w0.076: UC1.CM26 120.5,49.68 120.5,48.92
  BOTTOM w0.112: 120.5,48.92 120.57,48.85 120.57,46.58 v2(119.88,45.89) 119.19,45.2 RC65.2
GPU_PWR_LEVEL: length 154.1
  TOP w0.112: v1(123.72,127.4) 123.72,126.31 124.17,125.86 124.17,125.76 v2(125.27,124.66) 125.48,124.45 125.48,122.18 v1(126.04,121.61) 126.02,121.59 RV80.1 ; UE1.10 40.95,71.34 42.16,72.55 45.71,72.55 v1(45.96,72.3)
  IN2 w0.124: v1(46.9,103.18) 46.21,103.18 43.57,105.82 43.57,112.61 44.41,113.44 44.41,115.08 45.97,116.64 47.68,116.64 49.37,114.96 76.39,114.96 77.36,115.92 85.2,115.92 88.18,112.94 102.45,112.94 107.68,118.17 111.37,118.17 112.22,117.32 122.24,117.32 124.15,119.22 125.17,119.22 126.04,120.1 v1(126.04,121.61)
  IN3 w0.135: v1(45.96,72.3) 46.14,72.48 46.14,80.47 46.65,80.99 46.65,84.01 47.41,84.76 47.41,93.15 48.68,94.42 48.68,98.23 46.9,100.01 v1(46.9,103.18)
  BOTTOM w0.102: UV1.T9 v1(123.72,127.4)
GPU_VID1: length 14.2
  BOTTOM w0.102: 124.45,122.19 124.49,122.23 124.49,123.25 124.37,123.38 123.99,123.38 123.61,123.76 123.22,123.76 122.97,124.01 122.97,124.26 123.22,124.52 123.35,124.52 123.64,124.81 123.64,126.7 123.99,127.04 124.51,127.04 124.75,126.8 125,126.8 125.21,126.6 UV1.P8
  BOTTOM w0.112: 124.45,122.19 124.24,121.98 124.24,121.92 123.03,120.71 123.03,120.15 122.4,119.52 RV45.2 122.13,119.52 121.83,119.22 121.83,118.11 v2(121.37,117.65)
GPU_VID3: length 4.4
  BOTTOM w0.102: UV1.N1 126.54,122.19
  BOTTOM w0.112: RV44.2 124.68,119.43 125.01,119.75 125.01,120.5 v2(124.98,120.53) 124.98,120.53 125.33,120.87 126.01,120.87 126.54,121.41 126.54,122.19
H_CPUPWRGD: length 4.3
  BOTTOM w0.112: UC1.AR2 136.3,71.69 v2(138.63,71.69) 139.28,71.69 RC76.2
H_CPUPWRGD_R: length 0.9
  BOTTOM w0.112: TP20.1 RC76.1
H_PECI: length 2.7
  TOP w0.112: RE27.1 38.15,85.44 v2(38.15,85.05) UE1.94
H_PROCHOT#: length 338.5
  TOP w0.112: v1(205.29,51.47) 205.29,50.95 204.97,50.64 204.35,50.64 PQB32.1 204.25,50.29 204.36,50.17 PRB21.1 ; v1(39.08,88.89) 39.15,88.89 39.45,89.2 UE2.4 40.96,89.2 CE24.1 ; PQ11.1 167.47,35.94 PQ12.3 167.53,37.06 v1(167.49,37.1) ; v1(175.54,63.24) 175.54,62.87 175.68,62.73 PRZ43.2
  IN1 w0.119: v1(167.49,37.1) 167.78,37.39 171.48,37.39 171.69,37.61 171.69,39.22 171.07,39.84 171.07,45.36 171.74,46.03 174.41,46.03 175.42,47.05 175.42,49.78 174.47,50.73 174.47,51.56 173.71,52.32 173.39,52.32 172.63,53.08 172.63,60.76 172.78,60.92 177.61,60.92 178.85,62.16 178.85,62.96 178.57,63.24 v1(175.54,63.24) 171.57,63.24 169.66,65.15 169.66,70.02 165.66,74.02 154.23,74.02 148.45,79.79 144.07,79.79 143.18,80.69 142.95,80.69 v1(142.92,80.72) 142.92,80.76 143.43,81.27 143.43,94.16 142.82,94.76 142.82,104.03 139.19,107.67 133.85,107.67 130.15,111.37 124.3,111.37 121.92,113.76 113.75,113.76 112.48,115.03 95.95,115.03 v1(94.14,116.84) ; v1(205.29,51.47) 205.29,52.28 206,52.99 210.53,52.99 211.12,53.58 v1(211.46,53.58)
  IN3 w0.135: v1(211.46,53.58) 211.74,53.58 212.37,52.94 213.49,52.94 214.17,52.26 214.17,51.72 214.41,51.48 214.41,49.91 215.34,48.97 215.34,45.98 215.02,45.65 215.02,44.4 215.55,43.87 215.55,41.94 213.39,39.78 212.95,39.78 212.47,39.29 212.47,37.33 211.7,36.57 206.82,36.57 206.5,36.25 197.68,36.25 196.67,35.24 195.61,34.18 188.99,34.18 188.03,33.22 179.35,33.22 176.69,35.87 171.1,35.87 169.81,37.17 167.56,37.17 v1(167.49,37.1) ; v1(94.14,116.84) 94.04,116.74 91.68,116.74 90.72,117.7 88.73,117.7 86.34,120.09 77.13,120.09 75.76,121.46 69.45,121.46 69.07,121.85 58.96,121.85 58.66,122.15 54.15,122.15 v1(53.23,123.07)
  BOTTOM w0.076: 141.51,80.72 141.39,80.72 141.18,80.93 RC1.2 RC160.1
  BOTTOM w0.112: v1(39.08,88.89) 39.53,88.89 41.09,90.45 41.09,100.86 43.09,102.87 43.09,114.23 48.29,119.44 50.33,119.44 53.23,122.34 v1(53.23,123.07) ; 141.51,80.72 v1(142.92,80.72) ; v1(175.54,63.24) 175.15,62.85 PRZ49.2
H_PROCHOT#_R: length 8
  BOTTOM w0.076: UC1.Y4 134.84,81.21 134.42,81.21 134.35,81.28 134.35,81.49 134.43,81.57 134.76,81.57 134.8,81.62 135.06,81.62 135.09,81.59 135.8,81.59 135.94,81.45 137.33,81.45 137.57,81.69 138.02,81.69 138.1,81.62 138.1,80.83 138.17,80.75 138.32,80.75 138.44,80.87 v2(138.44,81.01) 138.44,81.62 138.51,81.69 139.05,81.69 RC160.2
H_THERMTRIP#: length 2.4
  BOTTOM w0.076: UC1.BJ1 136.74,63.84 137.09,63.84
  BOTTOM w0.102: RC2.2 138.54,63.84 137.09,63.84
H_VCCST_PWRGD: length 112.6
  TOP w0.112: UC8.4 96.53,43.1 95.65,42.22 94.78,42.22 94.43,41.88 91.26,41.88 90.78,41.4 90.78,40.83 91.54,40.06 91.54,39.33 92.4,38.47 92.88,38.47 93.77,37.58 93.77,36.41 95.79,34.39 95.79,32.06 v1(95.83,32.06) ; v1(134.15,36.31) 134.15,36.76 132.09,38.82 132.09,39.74 131.86,39.97 131.86,42.3 135.36,45.8 135.36,47.03 135.25,47.14 134.97,47.14 134.73,47.39 134.73,48.9 137.58,51.75 142.4,51.75 143.12,51.03 146.42,51.03 146.97,50.48 147.35,50.48 149.64,52.76 v2(149.64,56.28) 149.64,60.3 147.02,62.92 143.8,62.92 142.08,64.64 v1(142.08,64.77)
  IN3 w0.135: v1(95.83,32.06) 95.83,32.87 97.36,34.4 117.58,34.4 117.59,34.42 119.48,36.31 124.47,36.31 124.54,36.38 131.1,36.38 131.87,35.61 133.44,35.61 v1(134.15,36.31)
  BOTTOM w0.112: v1(142.08,64.77) 142.08,64.83 141.97,64.94 CC71.1 140.53,64.94 RC145.2 139.76,64.91 RC99.1
HDA_BIT_CLK: length 5.6
  BOTTOM w0.076: RC48.2 110.16,60.71 110.49,60.38 v2(110.73,60.38) 111.34,60.38 111.58,60.61 CC6.1 112.68,61.27 113.21,60.75 113.77,60.75 UC1.BN37
HDA_BIT_CLK_R: length 163
  TOP w0.112: v1(36.16,11.93) 36.53,11.93 RA8.2 36.53,12.44 35.85,12.44 v2(35.73,12.56) 35.48,12.81 UA1.5
  IN1 w0.119: v1(39.02,43.24) 38.89,43.37 32.17,43.37 25.97,37.17 24.51,35.71 24.51,33.94 33.56,24.89 36.15,24.89 36.98,24.06 36.98,19.82 37.83,18.97 37.83,17.26 38.26,16.82 38.26,13.56 36.63,11.93 v1(36.16,11.93)
  BOTTOM w0.112: RC48.1 106.13,60.71 104.78,62.07 103.16,62.07 100.7,59.6 100.7,58.76 101.13,58.33 101.13,48.96 98.45,46.28 98.45,45.07 97.79,44.41 97.79,43.94 97.79,43.54 95.47,41.21 94.6,41.21 92.64,39.25 92.37,39.25 92.37,39.25 91.23,39.25 89.53,37.55 89.53,34.72 91.6,32.65 91.6,27.17 90.88,26.45 68.83,26.45 63.47,31.81 59.66,31.81 57.31,34.16 57.31,35.36 56.8,35.88 55.06,35.88 54.59,36.35 47.69,36.35 46.16,37.87 44.39,37.87 v1(39.02,43.24)
HDA_SDIN0: length 157
  TOP w0.112: v1(37.04,13.7) 36.99,13.65 RA7.1
  IN1 w0.119: v1(112.49,60.83) 112.48,60.83 111.21,59.56 109.75,59.56 102.44,52.26 101.38,52.26 96.8,47.68 v1(96.8,47.3) ; v1(37.04,13.7) 37.5,14.16 37.5,15.3 37.27,15.53 36.89,15.53 35.78,16.64 35.78,20.32 36.23,20.77 36.23,23.21 35.53,23.91 33.49,23.91 23.76,33.63 23.76,36.02 32.56,44.82 40.11,44.82 v1(40.29,44.64)
  BOTTOM w0.076: UC1.BN35 114.95,60.63 114.48,60.63 114.36,60.67 114.12,60.67 113.88,60.58 112.74,60.58 v1(112.49,60.83)
  BOTTOM w0.112: v1(96.8,47.3) 96.58,47.08 96.58,44.04 94.96,42.42 94.1,42.42 92.14,40.46 90.7,40.46 88.58,38.34 88.19,38.34 87.54,37.69 87.54,32.95 87.92,32.57 88.06,32.57 88.59,32.04 88.59,29.82 88.95,29.46 88.95,28.75 88.46,28.26 78.74,28.26 73.65,33.35 60.28,33.35 60.17,33.46 60.17,35.44 58.52,37.09 55.56,37.09 55.09,37.56 48.19,37.56 46.66,39.08 45.53,39.08 40.29,44.32 v1(40.29,44.64)
HDA_SDIN0_R: length 1.3
  TOP w0.112: RA7.2 35.48,13.61 UA1.7
HDA_SDOUT: length 6.8
  BOTTOM w0.076: RC49.2 RC51.2 110.09,61.47 110.27,61.65 111.11,61.65 RC50.2 112.07,62.16 113.32,60.91 113.53,60.91 113.74,61.12 113.85,61.15 114.03,61.15 114.51,60.89 UC1.BN36
HDA_SDOUT_R: length 161
  TOP w0.112: UA1.4 35.1,12.41 v1(35.2,12.31)
  IN1 w0.119: v1(35.2,12.31) 35.53,12.31 36.1,12.89 36.87,12.89 37.76,13.77 37.76,16.62 37.33,17.05 37.33,18.76 36.48,19.61 36.48,23.36 35.69,24.15 33.59,24.15 24.01,33.74 24.01,35.91 31.97,43.87 v1(39.02,43.87)
  BOTTOM w0.112: v1(39.02,43.87) 39.72,43.87 45.23,38.37 46.37,38.37 47.89,36.84 54.79,36.84 55.27,36.37 57,36.37 57.8,35.57 57.8,34.37 59.78,32.39 63.59,32.39 69.04,26.94 90.67,26.94 91.1,27.37 91.1,32.43 89.04,34.5 89.04,37.76 91.02,39.75 92.13,39.75 92.13,39.74 92.17,39.74 92.17,39.75 92.44,39.75 94.4,41.71 95.26,41.71 97.3,43.74 97.3,44.61 97.96,45.27 97.96,46.49 100.63,49.16 100.63,57.7 99.93,58.4 99.93,59.53 102.96,62.56 105.09,62.56 105.38,62.26 108.51,62.26 RC49.1
HDA_SYNC: length 5.3
  BOTTOM w0.076: RC47.2 111.92,62.92 112.18,62.67 112.18,62.29 113.24,61.22 113.6,61.22 113.65,61.27 113.83,61.32 114.07,61.32 114.18,61.26 114.5,61.18 114.9,61.16 115.37,61.16 115.64,60.89 UC1.BN34
HDA_SYNC_R: length 162
  TOP w0.112: v1(34.96,15.81) 34.9,15.74 34.9,14.73 34.58,14.41 UA1.9
  IN1 w0.119: v1(40.1,45.21) 40.1,45.21 39.96,45.07 32.46,45.07 23.51,36.12 23.51,33.53 33.38,23.66 35.43,23.66 35.98,23.11 35.98,20.87 35.54,20.42 35.54,16.38 34.96,15.81 v1(34.96,15.81)
  BOTTOM w0.112: v1(40.1,45.21) 39.79,44.89 39.79,44.49 45.43,38.84 46.56,38.84 48.09,37.32 54.99,37.32 55.22,37.09 55.46,36.85 57.2,36.85 58.28,35.77 58.28,34.56 59.98,32.87 63.79,32.87 69.23,27.42 90.3,27.42 90.53,27.65 90.53,28.31 88.83,30 88.83,32.14 87.78,33.19 87.78,37.59 88.29,38.1 88.67,38.1 90.8,40.22 92.24,40.22 94.2,42.18 95.06,42.18 96.82,43.94 96.82,46.77 97.44,47.39 97.44,47.4 100.16,50.12 100.16,57.5 99.45,58.2 99.45,59.72 102.76,63.04 105.17,63.04 105.55,62.66 107.11,62.66 107.31,62.86 110.64,62.86 RC47.1
HDD_DET#: length 110.4
  TOP w0.112: v1(190.29,39.28) v2(190.85,39.28)
  IN2 w0.124: v1(122.64,40.83) 122.64,40.56 122.8,40.4 126.93,40.4 126.96,40.37 130.06,40.37 130.26,40.57 130.98,40.57 131.19,40.78 131.19,42.96 132.36,44.13 133.52,44.13 134.15,44.76 134.71,44.76 135.87,43.6 140.02,43.6 142.59,41.02 144.56,39.05 146.97,39.05 147.34,38.68 152.42,38.68 153.31,37.8 165.71,37.8 167.5,36.01 171.24,36.01 172.91,37.68 176.44,37.68 179.4,40.64 179.4,43.79 182,46.39 187.85,46.39 188.92,45.32 190.41,45.32 191.46,44.27 191.46,40.45 v1(190.29,39.28)
  IN3 w0.089: v1(123.89,52.54) 123.89,52.8 124.49,53.4 125.02,53.4 125.52,52.89 126.02,52.89 126.22,52.69
  IN3 w0.135: v1(122.64,40.83) 123.05,40.41 124.9,40.41 125.89,41.4 125.89,45.83 127.03,46.97 127.03,47.7 126.11,48.62 126.11,49.81 126.28,49.98 126.28,52.63 126.22,52.69
  BOTTOM w0.076: UC1.CG20 v1(123.89,52.54)
  BOTTOM w0.112: v1(190.29,39.28) 190.29,39.14 RC206.2 189.68,38.53 RS33.1
HDD_DEVSLP: length 93.7
  TOP w0.112: v1(133.7,42.48) 133.95,42.48 133.96,42.49 134.29,42.49 135.6,43.8 139.45,43.8 141.73,41.52 141.73,36.52 142.79,35.46 145,35.46 146.88,33.58 152.88,33.58 155.18,35.87 v2(157.08,35.87) 159.38,35.87 160.59,37.09 160.59,37.54 160.59,37.54 160.59,38.28 v1(160.98,38.67)
  IN2 w0.124: v1(160.98,38.67) 160.98,38.41 161.1,38.29 165.72,38.29 167.69,36.32 171.08,36.32 172.72,37.96 176.39,37.96 178.3,39.87 178.3,43.02 181.9,46.62 189.44,46.62 191.69,44.37 191.69,39.71 190.47,38.49 v1(190.47,37.9)
  BOTTOM w0.076: UC1.CP8 132.15,48.4 131.91,48.16 131.91,48.15 131.89,48.12 131.89,47.84 132.07,47.67 132.07,46.94 132.13,46.88 132.13,46.65 133.23,45.55 133.23,44.34 133.02,44.13 133.02,42.9 133.42,42.5
  BOTTOM w0.112: RS28.1 190.3,37.4 190.47,37.57 v1(190.47,37.9) ; 133.42,42.5 133.44,42.49 133.7,42.49 v1(133.7,42.48)
HDD_DEVSLP_R: length 4.4
  BOTTOM w0.112: JHDD1.8 v2(186.7,37.05) 186.7,37.25 186.85,37.4 RS28.2 187.57,37.67 187.69,37.78 RS33.2
HDMI_CLKN: length 3.7
  TOP w0.112: RI5.1 17.24,94.57 LI1.2 17.61,94.4 17.75,94.26 17.99,94.26 v1(18.18,94.44) 18.33,94.29 18.8,94.29 CI1.2
  BOTTOM w0.112: RI23.1 18.9,94.24 18.38,94.24 v1(18.18,94.44)
HDMI_CLKP: length 3.7
  TOP w0.112: RI1.1 17.24,93.73 LI1.3 17.61,93.9 17.74,94.03 18,94.03 v1(18.18,93.86) 18.39,94.07 18.8,94.07 CI2.2
  BOTTOM w0.112: v1(18.18,93.86) 18.34,94.02 18.98,94.02 RI24.1
HDMI_CTRL_CLK: length 30.5
  BOTTOM w0.112: QI3.6 26.19,89.34 26.4,89.54 RI14.1 26.4,90.41 26.02,90.79 25.16,90.79 25,90.62 v2(24.43,90.62) 24.23,90.62 23.69,91.16 22.63,91.16 22.31,90.84 22.31,89.69 21.65,89.03 20.04,89.03 19.83,88.82 16.98,88.82 13.91,91.89 13.91,100.68 13.14,101.44 12.2,101.44 11.72,100.96 11.72,100.02 JHDMI1.15
HDMI_CTRL_DAT: length 29.2
  IN3 w0.135: v1(28.67,88.04) 28.43,87.8 28.43,86.77 27.92,86.26 24.86,86.26 22.41,88.71 20.49,88.71 v1(20.1,88.32)
  BOTTOM w0.112: JHDMI1.16 13.41,99.04 13.41,91.69 16.77,88.32 v1(20.1,88.32) 20.31,88.54 20.7,88.54 RI15.1 ; QI3.3 v1(28.67,88.04)
HDMI_HPD: length 11.2
  BOTTOM w0.112: QI2.1 13.12,108.34 RI16.1 13.04,107.2 v2(13.5,106.74) 14.64,105.6 14.64,103.44 13.37,102.17 11.87,102.17 JHDMI1.19
HDMI_L_CLKN: length 7.1
  TOP w0.112: RI5.2 16.32,94.57 LI1.1 15.91,94.4 15.74,94.23 15.43,94.23 15.18,94.48 RI3.1 14.58,94.13 14.37,94.13 14.26,94.24 14.26,94.8 v4(13.97,95.09) 13.56,95.5 13.56,97.22 13.32,97.46 12.99,97.46 JHDMI1.12
HDMI_L_CLKP: length 7.1
  TOP w0.112: JHDMI1.10 12.99,97.24 13.23,97.24 13.34,97.13 13.34,95.41 13.57,95.17 13.57,95.14 14.04,94.68 14.04,94.15 14.28,93.91 14.58,93.91 RI3.2 15.2,93.56 15.65,94.01 15.78,94.01 15.89,93.9 LI1.4 16.32,93.73 RI1.2
HDMI_L_TX_N0: length 15.8
  TOP w0.112: RI2.2 16.32,96.6 LI2.1 15.91,96.43 15.75,96.27 15.49,96.27 15.18,96.57 RI4.1 14.57,96.22 14.43,96.22 14.21,96.44 14.21,97.21 14.2,97.22 14.2,98.27 13.98,98.49 v4(13.99,98.49) 13.75,98.73 13.75,100.85 12.94,101.66 12.26,101.66 11.68,101.08 11.68,96.08 11.56,95.96 11.44,95.96 JHDMI1.9
HDMI_L_TX_N1: length 6
  TOP w0.112: RI12.2 16.32,92.6 LI4.1 15.94,92.43 15.8,92.29 15.53,92.29 15.18,92.64 RI10.1 14.58,92.29 14.3,92.29 13.91,92.68 13.89,92.68 13.56,93.01 13.56,94.21 13.32,94.45 13,94.45 JHDMI1.6
HDMI_L_TX_N2: length 7.5
  TOP w0.112: JHDMI1.3 11.05,93.07 11.16,92.96 11.56,92.96 11.9,92.62 11.9,92.2 12.03,92.07 12.05,92.07 12.43,91.69 12.43,91.67 12.63,91.47 13.01,91.47 v4(13.34,91.14) 14.29,90.2 14.58,90.2 RI9.1 15.18,90.54 15.43,90.29 15.76,90.29 15.93,90.46 LI3.1 16.32,90.63 RI11.2
HDMI_L_TX_P0: length 15.8
  TOP w0.112: JHDMI1.7 11.44,95.74 11.65,95.74 11.9,95.99 11.9,100.99 12.36,101.44 12.84,101.44 13.53,100.75 13.53,98.62 13.98,98.18 v4(13.98,96.82) 13.98,96.36 14.33,96 14.58,96 RI4.2 15.18,95.66 15.56,96.05 15.78,96.05 15.9,95.93 LI2.4 16.32,95.76 RI6.2
HDMI_L_TX_P1: length 6
  TOP w0.112: JHDMI1.4 12.98,94.23 13.23,94.23 13.34,94.12 13.34,92.92 v4(13.93,92.33) 14.19,92.07 14.58,92.07 RI10.2 15.18,91.72 15.53,92.07 15.81,92.07 15.95,91.93 LI4.4 16.32,91.76 RI8.2
HDMI_L_TX_P2: length 7.5
  TOP w0.112: RI7.2 16.32,89.79 LI3.4 15.92,89.96 15.81,90.07 15.62,90.07 15.18,89.63 RI9.2 14.58,89.97 14.19,89.97 13.42,90.75 13.4,90.75 12.99,91.16 12.99,91.18 12.92,91.25 12.54,91.25 v4(12.07,91.71) 11.68,92.11 11.68,92.53 11.47,92.74 11.16,92.74 11.05,92.63 JHDMI1.1
HDMI_PLL_GND: length 23.2
  TOP w0.127: v2(29.43,91.79) 29.24,91.6 v1(27.83,91.6)
  TOP w0.508: QI1.1 27.54,91.89 v1(27.83,91.6)
  IN3 w0.508: v1(27.83,91.6) 27.09,91.6 25.71,90.23 24.16,90.23 23.15,89.21 20.99,89.21 20.01,90.19 20.01,92.39 20.78,93.15 v1(20.86,93.15)
  BOTTOM w0.508: RI20.2 RI19.2 RI18.2 RI17.2 20.23,92.51 v1(20.86,93.15) 20.23,93.78 RI24.2 RI23.2 RI22.2 RI21.2
