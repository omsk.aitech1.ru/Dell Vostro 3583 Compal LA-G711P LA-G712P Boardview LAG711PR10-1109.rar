# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N38038996: length 2
  TOP w0.102: RV41.2 127.4,123.38 127.36,123.34 CV99.1 126.68,122.93 v2(126.41,122.67)
N38349725: length 5.4
  TOP w0.254: RV39.2 v2(127.17,143.12) 127.7,143.12 128.58,142.25 v1(128.58,140.56)
  BOTTOM w0.3: v1(128.58,140.56) UV1.K25
N38996077: length 3.4
  BOTTOM w0.112: RV134.1 154.72,133.97 v2(154.44,134.25) 154.44,134.81 155.11,135.47 UV13.J1
N38996080: length 11.4
  TOP w0.112: RV135.1 v1(163.98,141.79) v2(164.4,141.37)
  BOTTOM w0.102: UV13.J10 155.11,143.09 156.66,141.54 162.18,141.54
  BOTTOM w0.112: 162.18,141.54 163.74,141.54 v1(163.98,141.79)
N40664383: length 2.1
  TOP w0.112: TP47.1 79.69,66.89 v1(80.43,66.89)
  BOTTOM w0.102: JDIMM1.165 80.17,66.99 80.3,66.86 80.4,66.86 v1(80.43,66.89)
N40665360: length 2.5
  TOP w0.112: TP49.1 65.15,66.8 v1(64.62,66.8)
  BOTTOM w0.089: JDIMM2.165 65.57,66.99 65.56,66.98 64.8,66.98 v1(64.62,66.8)
N40665398: length 2.1
  TOP w0.112: TP48.1 56.89,67.45 v1(56.89,67.73)
  BOTTOM w0.102: v1(56.89,67.73) 57,67.73 57,67.74 JDIMM2.162
N41527020: length 3.9
  TOP w0.112: v1(73.97,66.91) 73.95,66.89 TP46.1
  BOTTOM w0.102: v1(73.97,66.91) 73.14,67.74 JDIMM1.162
N45784517: length 4.8
  BOTTOM w0.203: PUZ01.41 179.2,56.5 179.29,56.59 v2(179.56,56.59)
  BOTTOM w0.254: PRZ06.2 PCZ02.1 182,56.39 PCZ09.1 PCZ08.1 180.31,56.59 v2(179.56,56.59)
N45784764: length 3.9
  BOTTOM w0.112: v2(181.73,58.38) 181.38,58.02 180.41,58.02 179.92,58.52 PRZ16.2
  BOTTOM w0.203: PUZ01.38 179.02,57.7 PRZ16.2
N45784907: length 7.7
  TOP w0.112: PCZ33.1 173.9,63.36 v2(174.49,63.36)
  TOP w0.254: PCZ33.1 173.47,62.07 PCZ26.2 174.05,61.49 174.05,60.65 v1(173.82,60.42)
  BOTTOM w0.203: PUZ01.28 174.43,59.51 173.83,60.11 173.83,60.41 v1(173.82,60.42) 173.82,60.56 173.45,60.94 173.45,61.23 PCZ27.2
  BOTTOM w0.254: PCZ27.2 173.43,62.06 PRZ51.2
N45784946: length 1.8
  TOP w0.112: PRZ01.1 v2(183.19,55.82)
  TOP w0.254: PRZ01.1 182.16,55.83 181.37,55.83 PCZ01.2
N45784991: length 1.8
  BOTTOM w0.112: PCZ13.1 v2(178.3,47.69)
  BOTTOM w0.203: PRZ20.2 PCZ13.1
N45785219: length 2.1
  TOP w0.112: v2(170.58,61.64) 171.03,62.09 PRZ61.2
  TOP w0.254: PCZ35.1 171.61,61.35 PRZ61.2
N45789065: length 1.8
  TOP w0.112: PRI03.2 v2(159.56,59.49)
N47599587: length 2
  TOP w0.112: PRZ24.2 v2(178.37,48.29)
  TOP w0.254: PCZ16.1 177.94,49.28 177.97,49.31 PRZ24.2
N47727863: length 3.8
  TOP w0.112: PRW11.2 v2(143.09,110.04)
  TOP w0.254: v1(144.43,110.82) 144.17,110.55 PRW11.2
  BOTTOM w0.254: PUW01.11 143.8,110.42 144.19,110.82 v1(144.43,110.82) 144.43,111.29 PCW11.1
N47727869: length 1.4
  BOTTOM w0.254: PCW10.1 142.66,110.79 142.9,110.55 PUW01.9
N47735962: length 4.4
  BOTTOM w0.112: v2(140.02,113.44) 140.51,112.96 140.51,111.78 PRW05.2
  BOTTOM w0.254: PUW01.7 141.68,110.07 140.95,110.81 PRW05.2
N47772279: length 1.9
  BOTTOM w0.112: v2(170.85,62.73) 171.15,63.04 PRZ55.1
  BOTTOM w0.254: PRZ55.1 PCZ31.2
N47887852: length 2.6
  TOP w0.112: PC1806.1 v2(201.14,56.28)
  TOP w0.508: PR1804.2 PC1806.1
N48572231: length 2.7
  BOTTOM w0.112: PCW14.2 147.23,114.49 148.47,114.49 v2(148.56,114.57)
  BOTTOM w0.254: PCW14.2 146.29,114.65 PRW13.1
N124752685: length 2.3
  TOP w0.112: RD13.1 72.37,62.67 v2(72.82,63.11)
  TOP w0.508: CD27.2 71.67,63.65 RD13.1
N124753277: length 1.9
  TOP w0.112: v2(60.03,66.26) 59.2,66.26 CD52.2 RD24.1
N124859178: length 1.6
  TOP w0.089: v1(132.8,73.56) 133.29,73.07 TP1.1
  BOTTOM w0.102: v1(132.8,73.56) 132.75,73.58 UC1.AM7
N295954310: length 34.8
  TOP w0.152: v1(178.85,58.8) v2(179.35,59.29) 180.69,59.29 PRZ10.1
  IN3 w0.152: v1(155.22,49.73) 154.59,50.35 154.59,54.8 155.74,55.94 158.53,55.94 159.41,56.82 160.13,56.82 161.09,57.78 168.37,57.78 170.09,59.49 176.27,59.49 176.97,58.8 v1(178.85,58.8)
  BOTTOM w0.152: PHZ01.2 v1(155.22,49.73)

## Copper pours and planes (outline as drawn)
+0.6V_DDR_VTT on TOP (solid shape): 41.69,37.9 41.69,37.08 40.48,35.87 39.15,35.87 38.96,36.06 38.96,36.7 40.48,38.22 41.37,38.22
+0.6V_DDR_VTT on TOP (solid shape): 74.46,43.94 74.46,42.98 72.87,41.4 72.3,41.4 71.92,41.78 71.92,41.97 72.23,42.29 72.23,44.06 72.32,44.15 74.24,44.15
+0.6V_DDR_VTT on TOP (solid shape): 61.25,44.52 61.25,41.78 62.06,40.96 62.06,40.5 61.88,40.32 61.88,40.32 58.97,40.32 57.6,41.69 57.6,42.33 58.96,43.7 58.96,44.11 59.05,44.19 59.81,44.19 60.21,44.6 61.17,44.6
+0.6V_DDR_VTT on BOTTOM (solid shape): 61.4,43.54 61.4,43.11 61.21,42.92 59.74,42.92 59.07,43.59 57.43,43.59 57.36,43.66 57.36,43.8 57.45,43.89 61.04,43.89
+0.6V_DDR_VTT on BOTTOM (solid shape): 73.49,43.66 73.49,42.74 73.3,42.55 72.27,42.55 72.11,42.72 72.11,43.26 71.8,43.58 70.17,43.58 70.07,43.68 70.07,43.79 70.17,43.89 71.78,43.89 71.8,43.91 73.24,43.91
+0.6VSP on TOP (solid shape): 39.59,35.11 40.1,35.11 40.1,35.68 40.55,35.68 40.74,35.49 40.74,34.79 40.23,34.29 40.23,32 39.91,31.68 39.48,31.68 39.47,31.67 39.43,31.67 39.16,31.4 39.16,31.29 38.84,30.97 38.84,29.56 38.79,29.5 37.99,29.5 37.94,29.55 37.94,30.66 38.16,30.88 38.23,30.94 38.29,31.01 38.34,31.06 38.34,31.43 38.21,31.56 37.71,31.56 37.57,31.42 37.57,31.09 37.36,30.88 37.36,29.97 37.3,29.9 37.19,29.9 37.13,29.97 37.13,31.03 37.32,31.22 37.32,31.82 37.5,32 38.2,32 38.83,32.63 38.83,35.3 39.21,35.68 39.59,35.68
+0.95VSDGPU on TOP (solid shape): outline of 231 points within 119.09,139.63 122.78,146.07
+0.95VSDGPU on BOTTOM (solid shape): 118.58,119.83 118.58,119.44 118.54,119.43 118.35,119.07 118.73,118.91 118.75,118.88 118.78,118.85 118.78,118.68 120.05,117.41 121.23,117.41 121.24,117.4 121.37,117.37 121.5,117.4 121.51,117.41 122.58,117.41 122.59,117.4 122.72,117.37 122.86,117.4 122.87,117.41 123.03,117.41 124.56,115.88 124.56,113.91 124.3,113.66 123.73,113.66 123.73,114.23 122.34,114.23 122.34,113.66 120.87,113.66 120.18,114.36 117.32,114.36 115.86,115.82 115.86,119.76 116.18,120.07 118.33,120.07
+0.95VSDGPU on IN1: 113.97,118.7 113.52,119.15 111.96,120.7 111.95,120.7 109.44,123.2 109.44,130.23 109.45,130.24 109.45,141.52 114.04,146.11 120.62,146.11 121.13,145.6 121.13,143.67 115.1,137.64 115.1,124.14 118.4,120.84 118.4,119.21 117.89,118.7
+0.95VSDGPU_OUT on BOTTOM (solid shape): 124.24,113.22 124.24,111.88 123.54,111.18 119.8,111.18 119.73,111.25 119.73,112.33 120.1,112.7 120.18,112.73 120.26,112.68 120.64,112.59 120.74,112.97 120.72,113 120.91,113.2 120.91,113.5 123.95,113.5
+1.2V_DDR on TOP (solid shape): 89.84,58.14 81.84,58.14 81.84,66.14 89.84,66.14
+1.2V_DDR on TOP (solid shape): 102.54,66.72 94.54,66.72 94.54,74.72 102.54,74.72
+1.2V_DDR on TOP (solid shape): outline of 27260 points within 45.4,46.92 117.57,109.02
+1.2V_DDR on BOTTOM (solid shape): 46.64,33.56 46.3,33.1 46.85,32.91 46.85,32.36 46.53,32.04 45.75,32.04 45.75,32.56 45.05,32.56 45.05,32.04 44.55,32.04 44.55,32.56 43.85,32.56 43.85,32.04 42.65,32.04 42.38,32.31 42.38,34.2 42.61,34.43 45.78,34.43
+1.2V_DDR on BOTTOM (solid shape): outline of 325 points within 67.29,67.29 71.92,82.21
+1.2V_DDR on BOTTOM (solid shape): outline of 374 points within 78.11,71.33 84.13,82.78
+1.2V_DDR on BOTTOM (solid shape): outline of 471 points within 55.81,68.04 59.1,82.53
+1.2V_DDR on IN1: 113.34,70.57 117.46,70.57 117.71,70.32 117.71,65.62 115.54,63.45 113.07,63.45 112.81,63.7 112.81,70.05
+1.2V_DDR on VCC: 41.8,32.82 40.04,34.58 40.04,51.26 42.81,54.03 47.17,54.03 47.28,53.93 47.28,33.95 46.16,32.82
+1.2VP on TOP (solid shape): 35.23,33.37 35.23,32.53 35.3,32.47 36.19,32.47 36.19,30.87 36.15,30.84 36.15,29.97 36.09,29.91 36,29.91 35.94,29.96 35.94,30.63 35.51,31.06 35.51,31.77 35.32,31.96 34.69,31.96 34.69,33.37 34.73,33.41 35.2,33.41
+1.2VP on TOP (solid shape): 54.59,32.23 54.59,31.68 56.19,30.09 56.19,29.4 56.09,29.28 56.07,29.13 56.04,29.05 55.97,29.01 52.66,29.01 52.4,29.27 52.4,30.46 52.22,30.65 42.58,30.65 42.57,30.66 42.43,30.69 42.29,30.66 42.28,30.65 42.09,30.65 41.69,31.05 39.35,31.05 39.29,31.11 39.29,31.35 39.48,31.54 40.15,31.54 40.78,32.17 51.5,32.17 52.15,32.82 54,32.82
+1.2VP on BOTTOM (solid shape): 54.62,31.96 54.62,31.58 56.28,29.92 56.28,25.02 56.07,24.8 52.69,24.8 51.8,25.69 51.8,28.76 50.61,29.95 44.04,29.95 44.03,29.99 43.77,30.24 43.43,30.14 43.36,30.11 43.29,30.14 43.17,30.25 43.17,30.88 43.17,30.88 43.17,31.83 43.23,31.89 43.95,31.89 43.95,31.92 43.97,31.92 43.97,32.43 43.98,32.44 44.42,32.44 44.42,31.92 44.45,31.92 44.45,31.91 45.15,31.91 45.15,31.92 45.17,31.92 45.17,32.44 45.6,32.44 45.61,32.42 45.61,31.89 46.66,31.89 46.95,32.18 50.93,32.18 50.94,32.19 51.53,32.19 52.17,32.82 53.76,32.82
+1.05V_MPHY on TOP (solid shape): 129.49,58.43 129.49,58.14 130.42,58.14 130.46,58.1 130.46,56.26 130.38,56.18 129.2,56.18 129.06,56.32 128.32,56.32 127.99,56.65 127.99,57.07 128.11,57.19 128.44,57.19 128.69,57.45 128.7,57.52 128.7,58.28 128.87,58.46 129.13,58.46 129.13,58.47 129.46,58.47
+1.05V_PRIM on TOP (solid shape): 150.53,48.13 150.53,47.62 149.96,47.62 149.96,45.59 150.53,45.59 150.53,45.02 151.8,43.75 151.8,40.32 152.05,40.06 152.56,40.06 153.07,39.56 153.88,39.56 154.08,39.35 154.08,38.86 154.01,38.79 150.28,38.79 150.02,39.05 150.02,41.46 149.2,42.29 149.2,43.37 148.94,43.62 148.69,43.62 147.48,44.83 147.48,47.94 147.99,48.45 150.21,48.45
+1.05V_PRIM on TOP (solid shape): outline of 379 points within 123.64,55.39 130.4,61.16
+1.05V_PRIM on BOTTOM (solid shape): 129.13,105.41 129.13,104.77 128.94,104.58 128.18,104.58 127.92,104.83 127.92,105.85 127.99,105.91 128.62,105.91
+1.05V_PRIM on BOTTOM (solid shape): 129.19,109.34 129.19,107.5 129,107.31 127.99,107.31 127.92,107.37 127.92,108.26 128.3,108.64 128.3,108.85 128.37,108.85 128.37,109.46 128.33,109.46 128.33,109.5 128.37,109.53 129,109.53
+1.05V_PRIM on BOTTOM (solid shape): 122.14,109.72 122.14,108.45 121.83,108.14 120.24,108.14 119.83,108.54 119.8,108.65 119.72,108.74 119.72,109.87 119.76,109.91 120.33,109.91 120.33,109.91 121.07,109.91 121.08,109.91 121.95,109.91
+1.05V_PRIM on VCC: 148.48,44.64 143.41,49.7 127.73,49.7 123.54,53.89 123.54,60.51 127.82,60.51 130.1,58.22 141.03,58.22 142.11,57.15 146.87,57.15 151.88,52.13 154.83,52.13 155.61,52.91 155.61,67.52 158.28,70.18 158.28,83.73 155.33,86.67 152.82,86.67 152.82,102.78 151.02,104.58 123.71,104.58 120.18,108.11 120.18,110.44 120.66,110.93 128.96,110.93 132.14,107.75 152.58,107.75 155.36,104.98 155.36,90.89 160.56,85.68 160.56,68.36 158.66,66.46 158.66,52.36 154.85,48.55 154.85,45.25 154.23,44.64
+1.05V_PRIM on IN2: outline of 269 points within 123.48,43.68 150.78,60.51
+1.05VALWP on TOP (solid shape): 153.58,49.02 153.58,45.46 152.94,44.83 150.97,44.83 150.72,45.08 150.72,48.19 149.51,49.4 149.51,49.97 149.58,50.03 152.56,50.03
+1.05VALWP on BOTTOM (solid shape): 153.45,49.14 153.45,43.87 153.07,43.49 150.21,43.49 150.02,43.68 150.02,48.26 149.57,48.71 149.57,50.03 149.58,50.03 152.56,50.03
+1.8V_AVDD on TOP (solid shape): 30.77,10.85 30.77,9.84 30.32,9.39 30.32,8 29.76,7.44 28.78,7.44 28.76,7.47 28.76,8.04 28.91,8.19 29.75,8.19 29.98,8.42 29.98,9.41 30.56,9.99 30.56,10.85 30.61,10.9 30.72,10.9
+1.8V_CPVDD on TOP (solid shape): 29.55,11.67 29.55,11.57 29.5,11.51 28.66,11.51 28,10.85 27.48,10.85 26.98,10.35 26.4,10.35 26.27,10.48 26.27,11.49 26.5,11.72 29.5,11.72
+1.8V_PRIM on TOP (solid shape): 41.25,119.38 41.25,118.93 40.86,118.55 40.55,118.55 39.28,119.82 39.28,120.33 39.59,120.65 39.98,120.65
+1.8V_PRIM on TOP (solid shape): 45.69,114.87 45.69,114.23 45.56,114.1 44.74,114.1 44.55,114.3 44.55,114.55 43.79,115.31 43.79,115.82 44.04,116.07 44.48,116.07
+1.8V_PRIM on TOP (solid shape): 55.66,77.6 55.66,76.59 55.61,76.54 55.11,76.54 55.03,76.62 55.02,76.64 54.87,76.89 54.58,76.94 54.5,76.96 54.46,77.04 54.46,77.6 54.55,77.69 55.57,77.69
+1.8V_PRIM on TOP (solid shape): 20.89,126.52 20.89,125.9 20.83,125.84 20.23,125.84 20.17,125.78 20.17,124.91 20.31,124.78 21.42,124.78 21.73,124.47 21.73,123.69 21.66,123.62 20.96,123.62 20.96,123.62 19.56,123.62 18.51,124.67 17.55,124.67 17.41,124.81 17.41,126.3 17.46,126.35 18.64,126.35 18.84,126.55 20.86,126.55
+1.8V_PRIM on TOP (solid shape): 127.7,54.5 127.7,54.29 127.68,54.27 127.52,54.04 127.64,53.79 127.64,53.5 127.55,53.41 127.51,53.4 127.47,53.38 124.49,53.38 124.49,54.54 124.53,54.58 126.05,54.58 126.13,54.5 126.13,54.12 126.28,53.97 126.84,53.97 126.94,54.07 126.94,54.5 127.07,54.63 127.58,54.63
+1.8V_PRIM on TOP (solid shape): 31.93,22.02 34.57,22.02 34.71,22.16 35.05,22.16 35.12,22.13 35.15,22.05 35.32,21.75 35.68,21.74 35.7,21.74 37.18,20.25 37.37,20.25 37.63,20 37.63,19.36 37.37,19.11 36.04,19.11 35.66,19.49 35.66,20.44 35.21,20.89 31.72,20.89 31.4,21.2 31.4,21.97 31.59,22.16 31.79,22.16
+1.8V_PRIM on BOTTOM (solid shape): 47.66,115.37 47.66,114.87 46.64,113.85 44.74,113.85 44.47,114.12 44.47,114.36 46.39,116.28 46.75,116.28
+1.8V_PRIM on BOTTOM (solid shape): 193.9,61.84 193.9,61.46 193.33,61.46 193.33,60.07 193.9,60.07 193.9,59.75 193.84,59.69 192.19,59.69 191.87,60 191.87,61.78 192.12,62.03 193.71,62.03
+1.8V_PRIM on BOTTOM (solid shape): 112.62,113.15 112.62,111.58 114.29,109.91 118.27,109.91 118.33,109.85 118.33,109.22 117.7,108.58 113.05,108.58 110.89,110.74 110.89,112.95 111.35,113.41 112.37,113.41
+1.8V_PRIM on BOTTOM (solid shape): 125.55,54.65 125.77,54.65 125.8,54.68 125.81,54.68 125.92,54.74 125.99,54.83 126.21,54.83 126.31,54.73 126.31,54.58 126.38,54.06 126.87,54.26 126.87,54.27 127.02,54.42 127.03,54.43 127.15,54.49 127.21,54.61 127.22,54.62 127.25,54.65 127.5,54.65 127.62,54.76 127.66,54.81 127.7,54.86 127.88,54.86 127.89,54.85 127.95,54.76 128.04,54.7 128.04,54.69 128.09,54.65 128.09,54.03 128.01,53.97 127.95,53.89 127.95,53.88 127.51,53.45 127.5,53.44 127.42,53.42 127.36,53.38 126.65,53.38 126.49,53.45 126.32,53.38 125.62,53.38 125.45,53.45 125.28,53.38 125.04,53.38 124.78,53.64 124.78,54.78 124.91,54.91 125.29,54.91
+1.8V_PRIM on IN1 (solid shape): 55.79,47.94 55.79,47.58 55.64,47.43 53.25,47.43 51.87,48.81 51.87,49.35 52.23,49.72 54.01,49.72
+1.8V_PRIM on IN2 (solid shape): 112.79,113.09 112.55,112.85 111.35,112.85 111.16,113.05 111.16,114.17 111.92,114.93 112.79,114.93
+1.8V_PRIM on IN2 (solid shape): 54.48,49.5 54.48,49.32 56.55,47.25 56.55,46.67 56.42,46.54 55.66,46.54 55.58,46.62 55.58,46.78 53.46,48.9 53.46,49.43 53.76,49.72 54.26,49.72
+1.8V_PRIM on IN3 (solid shape): 40.48,120.01 40.48,119.63 40.17,119.31 39.72,119.31 38.39,120.65 38.39,120.96 38.83,121.41 39.09,121.41
+1.8V_PRIM on IN3 (solid shape): 32.55,22.22 32.55,21.52 32.42,21.39 31.47,21.39 31.34,21.52 31.34,21.97 30.9,22.41 30.9,22.66 31.28,23.05 31.72,23.05
+1.8V_PRIM on IN1: 38.41,51.6 38.41,50.88 38.2,50.67 36.62,50.67 36.42,50.87 36.42,51.75 36.61,51.94 38.07,51.94
+1.8V_PRIM on IN1: 121.88,42.52 123.22,42.52 123.51,42.81 123.51,43.33 123.47,43.37 123.47,43.68 124.79,45 124.79,48.14 124.6,48.34 122.57,48.34 122.21,47.98 122.21,44.56 121.52,43.87 121.52,42.88
+1.8V_PRIM on IN2: 193.2,61.78 193.2,60 190.53,57.34 189.9,57.34 189.01,58.22 189.01,58.86 190.41,60.26 190.79,60.26 191.17,60.64 191.17,62.29 191.55,62.67 191.93,62.67 192.44,62.16 192.82,62.16
+1.8V_PRIM on IN2: outline of 529 points within 89.12,38.44 183.87,57.91
+1.8V_PRIM on IN2: 36.11,41.54 37.24,41.54 37.56,41.86 37.56,52.28 37.53,52.32 36.17,52.32 35.97,52.12 35.97,41.68
+1.8V_PRIM on IN3: 30.82,129.42 31.53,128.71 31.53,126.93 31.09,126.49 25.75,126.49 24.48,127.76 21.69,127.76 20.93,127 20.93,126.17 20.54,125.79 19.38,125.79 18.76,126.41 18.76,128.96 19.22,129.42
+1.8V_PRIM on IN3: 35.86,39.77 36.22,39.77 37.56,41.1 37.56,41.72 37.18,42.1 36.58,42.1 36.57,42.09 36.32,42.09 36.14,41.91 36.14,41.66 35.26,40.77 35.26,40.37
+1.8VALWP on TOP (solid shape): 197.39,60.96 197.39,60 197.27,59.88 196.12,59.88 196,60 196,60.89 196.12,61.02 197.33,61.02
+1.8VALWP on BOTTOM (solid shape): 195.6,62.23 195.93,61.74 196.26,62.23 197.33,62.23 197.39,62.16 197.39,59.81 197.9,59.3 198.85,59.3 199.04,59.11 199.04,56.95 198.85,56.76 195.68,56.76 194.09,58.35 194.09,61.91 194.41,62.23
+1.8VGS on TOP (solid shape): outline of 435 points within 107.01,119.25 115.99,143.25
+1.8VGS on BOTTOM (solid shape): 115.6,119.95 115.6,115.76 116.18,115.18 116.18,113.72 116.11,113.66 115.79,113.66 115.79,114.23 114.4,114.23 114.4,113.66 112.75,113.66 112.11,114.3 112.11,119.82 112.43,120.14 115.41,120.14
+1.8VGS_OUT on BOTTOM (solid shape): 118.08,113.36 118.08,112.45 118.33,112.2 118.33,111.25 118.27,111.18 114.4,111.18 113.7,111.88 113.7,113.41 113.79,113.5 117.94,113.5
+1.35V_MEM_GFX on TOP (solid shape): 128.56,131.5 128.56,130.56 128.59,130.53 128.62,130.49 129.13,129.98 129.13,129.29 128.35,128.52 128.34,128.52 128.34,128.51 128.29,128.46 128.29,127.83 128.33,127.8 129.05,127.8 129.07,127.81 129.18,127.81 129.18,128.04 129.62,128.04 129.74,127.92 129.74,126.96 129.59,126.81 128.24,126.81 128,127.05 127.97,127.09 127.97,127.14 128.1,127.42 127.87,127.62 127.83,127.66 127.83,127.72 127.83,127.81 127.8,127.91 127.8,127.92 127.8,128.91 127.8,130.86 127.8,131.12 127.79,131.13 127.79,131.21 127.72,131.27 127.64,131.27 127.48,131.44 127.48,131.63 127.67,131.82 128.24,131.82
+1.35V_MEM_GFX on TOP (solid shape): 129.55,139.19 129.55,138.53 129.52,138.45 129.44,138.43 129.06,138.19 129.2,137.77 129.25,137.7 129.22,137.61 128.96,137.36 128.95,137.35 128.76,137.05 128.93,136.73 128.93,136.27 129.08,136.12 129.08,135.76 128.94,135.62 128.93,135.62 128.88,135.57 128.73,135.57 128.7,135.6 128.7,135.62 128.57,135.74 128.56,135.74 128.51,135.79 127.96,135.79 127.87,135.87 127.87,137.49 127.74,137.63 127.74,138.23 127.63,138.34 127.63,138.42 127.51,138.54 127.51,138.89 127.56,138.94 128.18,138.94 128.61,139.37 129.37,139.37
+1.35V_MEM_GFX on TOP (solid shape): outline of 2601 points within 155.35,114.99 164.56,149.5
+1.35V_MEM_GFX on BOTTOM (solid shape): 160.75,121.44 160.83,121.41 160.86,121.33 160.94,121.11 161.15,120.99 161.21,120.96 161.24,120.89 161.3,120.73 161.44,120.64 161.46,120.64 161.54,120.55 161.57,120.45 161.48,120.38 161.3,120.28 161.24,120.09 161.24,120.07 161.2,120.03 161.13,120.04 161.09,120.04 161.02,120.06 160.98,120.13 160.9,120.3 160.74,120.38 160.67,120.41 160.65,120.49 160.56,120.72 160.33,120.83 160.31,120.83 160.23,120.91 160.28,120.97 160.3,120.96 160.56,121.06 160.65,121.33 160.67,121.4 160.74,121.44
+1.35V_MEM_GFX on BOTTOM (solid shape): 127.87,131.77 128.02,131.66 128.21,131.65 128.23,131.65 128.78,131.1 128.78,130.66 128.66,130.28 129.02,130.1 129.1,130.08 129.14,130 129.14,129.78 129.12,129.75 129.12,129.6 129.08,129.52 129,129.5 128.64,129.26 128.87,128.9 128.88,128.9 129,128.78 128.99,128.76 129.12,128.42 129.48,128.4 129.49,128.41 129.8,128.41 129.89,128.32 129.89,127.17 129.51,126.79 129.1,126.79 129.07,126.82 129.02,126.84 128.72,127.14 128.72,127.99 127.77,128.94 127.77,131.15 127.61,131.31 127.61,131.32 127.58,131.35 127.52,131.5 127.57,131.65 127.59,131.67 127.69,131.77
+1.35V_MEM_GFX on BOTTOM (solid shape): 129.9,139.53 129.9,139.21 129.82,138.99 129.9,138.78 129.9,138.55 129.72,138.36 129.55,138.36 129.54,138.37 129.41,138.4 129.27,138.38 129.12,138.27 129.06,138.09 129.06,138.08 128.88,137.9 128.87,137.89 128.64,137.64 128.79,137.33 128.84,137.27 128.83,137.2 128.79,137.09 128.79,136.98 128.8,136.95 128.77,136.93 128.77,136.65 128.65,136.3 128.97,136.09 129.01,136.09 129.11,135.99 129.11,135.63 128.99,135.5 128.96,135.5 128.84,135.49 128.74,135.43 128.08,135.43 128,135.51 128,135.58 127.96,135.62 127.89,135.8 127.96,135.98 128,136.01 128,136.58 127.96,136.62 127.91,136.7 127.89,136.79 127.89,136.86 127.87,136.88 127.87,138.03 128.36,138.52 128.36,139.49 128.52,139.64 129.79,139.64
+1.35V_MEM_GFX on BOTTOM (solid shape): 149.24,121.75 149.24,121.73 149.29,121.55 149.51,121.4 149.53,121.33 149.61,121.09 149.85,120.98 149.87,120.98 149.97,120.88 149.92,120.83 149.9,120.82 149.68,120.72 149.56,120.41 149.49,120.38 149.3,120.29 149.24,120.08 149.24,120.06 149.18,120 149.12,120.02 149.08,120.02 149.01,120.05 148.98,120.12 148.89,120.32 148.67,120.38 148.63,120.39 148.61,120.44 148.62,120.49 148.76,120.64 148.78,120.64 148.98,120.93 148.73,121.18 148.66,121.21 148.64,121.29 148.64,121.33 148.66,121.4 148.73,121.43 148.9,121.52 149.01,121.75 149.07,121.78 149.11,121.79 149.18,121.81
+1.35V_MEM_GFX on BOTTOM (solid shape): 159.6,121.75 159.64,121.68 159.7,121.53 159.84,121.44 159.85,121.44 159.99,121.3 160,121.24 159.98,121.19 159.94,121.18 159.64,120.96 159.84,120.64 159.85,120.64 159.98,120.51 159.96,120.41 159.7,120.29 159.64,120.09 159.64,120.07 159.6,120.03 159.53,120.04 159.49,120.04 159.42,120.06 159.38,120.13 159.09,120.38 158.84,120.09 158.84,120.07 158.8,120.03 158.73,120.04 158.69,120.04 158.62,120.06 158.58,120.13 158.5,120.3 158.33,120.38 158.26,120.41 158.24,120.49 158.24,120.51 158.37,120.64 158.38,120.64 158.52,120.73 158.58,120.89 158.61,120.95 158.67,120.98 158.87,121.1 158.95,121.33 158.98,121.41 159.06,121.44 159.28,121.49 159.38,121.68 159.42,121.75 159.49,121.78 159.53,121.78
+1.35V_MEM_GFX on BOTTOM (solid shape): 150.84,121.75 150.84,121.73 151.09,121.43 151.38,121.7 151.41,121.77 151.49,121.8 151.52,121.8 151.6,121.77 151.64,121.7 151.71,121.52 151.89,121.43 151.96,121.4 151.98,121.33 151.98,121.29 151.96,121.21 151.89,121.18 151.64,120.93 151.84,120.64 151.85,120.64 151.99,120.5 152,120.44 151.98,120.39 151.94,120.38 151.72,120.3 151.64,120.08 151.64,120.06 151.58,120 151.52,120.02 151.48,120.02 151.41,120.05 151.38,120.12 151.31,120.29 151.14,120.38 151.08,120.41 151.05,120.48 150.95,120.73 150.69,120.82 150.62,120.85 150.58,120.92 150.5,121.1 150.33,121.18 150.31,121.18 150.19,121.3 150.19,121.31 150.31,121.43 150.33,121.43 150.5,121.52 150.58,121.7 150.61,121.77 150.68,121.8 150.72,121.8 150.78,121.81
+1.35V_MEM_GFX on BOTTOM (solid shape): outline of 380 points within 153.14,141.71 164.44,149.49
+1.35V_MEM_GFX on BOTTOM (solid shape): outline of 1413 points within 147.95,112 164.59,124.62
+1.35V_MEM_GFX on BOTTOM (solid shape): outline of 3809 points within 147.97,124.39 164.63,144.52
+1.35V_MEM_GFX on IN1: 131.52,136.24 131.36,135.94 131.52,135.64 131.52,134.97 131.14,134.69 131.41,134.31 131.45,134.3 131.52,134.27 131.52,133.81 131.38,133.53 131.52,133.25 131.52,132.73 131.52,132.73 131.53,132.47 131.71,132.28 131.74,132.27 131.74,127.62 131.36,127.24 131.2,127.24 130.87,127.35 130.61,127.13 130.6,127.12 130.28,126.79 128.57,126.79 128.24,127.12 128.24,128.77 127.49,129.53 127.49,131.68 128.06,132.25 128.06,132.38 128.07,132.47 128.06,132.57 128.06,139.56 128.44,139.94 130.47,139.94 130.68,139.73 130.68,139.71 130.88,139.45 131.21,139.46 131.25,139.48 131.52,139.21 131.52,139.16 131.51,139.15 131.44,138.93 131.52,138.72 131.52,138.51 131.38,138.23 131.52,137.95 131.52,137.49 131.49,137.47 131.31,137.16 131.49,136.85 131.52,136.83 131.52,136.71 131.52,136.7 131.5,136.59 131.52,136.48 131.52,136.47
+1.35V_MEM_GFX on VCC: 148.86,115.12 144.43,119.55 126.49,119.55 126.49,124.9 128.4,126.81 128.4,128.93 127.13,130.2 127.13,131.25 128.4,132.52 128.4,134.64 126.49,136.55 126.49,147.12 132.47,147.12 136.28,150.93 154.61,150.93 155.12,150.43 161.47,150.43 165.13,146.77 165.13,131.14 165.77,130.51 165.77,118.27 165.28,117.79 163.5,117.79 160.84,115.12
+1.35V_MEM_GFX on IN3: outline of 124 points within 127.5,126.73 132.74,140.02
+1.35VGPUP on TOP (solid shape): 158.01,111.95 158.01,109.16 157.62,108.77 153.78,108.77 153.59,108.96 153.59,112.06 153.65,112.12 157.83,112.12
+1.35VGPUP on BOTTOM (solid shape): 155.84,111.85 159.13,111.85 159.27,111.71 159.27,110.43 157.46,108.63 150.8,108.63 150.64,108.79 150.64,111.78 150.9,112.04 155.64,112.04
+2.5V_MEM on TOP (solid shape): 60.03,112.87 60.03,110.77 59.85,110.59 58.73,110.59 58.44,110.88 58.44,112.82 58.67,113.05 59.85,113.05
+2.5V_MEM on TOP (solid shape): 68.36,44.51 68.36,44.13 68.55,43.94 68.55,43.56 68.36,43.37 66.96,43.37 66.58,43.75 66.58,44.51 66.7,44.62 68.25,44.62
+2.5V_MEM on TOP (solid shape): 80.67,44.9 80.67,43.89 80.27,43.49 77.88,43.49 77.74,43.63 77.74,44.34 78.1,44.7 79.09,44.7 79.43,45.04 80.53,45.04
+2.5V_MEM on BOTTOM (solid shape): 59.77,112.08 59.77,111.06 59.58,110.86 55.25,110.86 55.04,111.07 55.04,111.76 55.67,112.38 59.47,112.38
+2.5V_MEM on BOTTOM (solid shape): 55.79,52.38 55.79,51.62 56.04,51.37 56.04,50.48 55.91,50.35 55.15,50.35 54.77,50.73 54.77,52.51 55.66,52.51
+2.5V_MEM on BOTTOM (solid shape): 68.12,44.14 68.28,44.14 68.55,43.87 68.55,43.49 68.29,43.23 65.66,43.23 65.56,43.34 65.56,44.04 65.67,44.15 68.11,44.15
+2.5V_MEM on BOTTOM (solid shape): 81.16,44.25 81.16,43.14 81,42.98 78.51,42.98 78.5,43 78.43,43.2 78.26,43.32 78.19,43.39 77.85,43.39 77.67,43.56 77.67,44 77.81,44.14 80.04,44.14 80.25,44.35 81.06,44.35
+2.5V_MEM on IN3: 64.25,42.43 62.65,40.83 59.34,40.83 54.39,45.78 54.39,51.37 55.03,52 58.45,52 59.09,51.37 59.09,46.1 60.94,44.25 68.17,44.25 68.68,43.75 70.07,43.75 70.75,44.42 81.11,44.42 81.25,44.28 81.25,43.49 81.12,43.37 72.27,43.37 71.33,42.43
+2.5V_PG on TOP (solid shape): 72.56,110.74 72.56,110.26 72.3,110 71.89,110 71.69,109.8 71.69,108.04 71.51,107.85 69.64,107.85 69.54,107.96 69.54,109.05 70.43,109.94 70.43,110.68 70.63,110.87 72.42,110.87
+2.5VP on TOP (solid shape): 65.65,113.34 67.1,113.34 67.29,113.14 67.29,112.82 67.05,112.58 65.55,112.58 65,112.03 62.63,112.03 61.75,111.88 61.3,111.1 61.19,110.99 61.08,110.99 60.73,111.3 60.37,110.99 60.33,110.99 60.19,111.14 60.19,111.96 60.74,111.96 60.74,112.44 60.19,112.44 60.19,113.45 60.64,113.9 65.09,113.9
+3.3V_SPI on IN1: 122.12,58.21 123.39,58.21 123.64,57.95 123.64,57.45 123.51,57.32 121.23,57.32 120.34,58.21 116.66,58.21 116.02,58.84 116.02,59.75 116.39,60.11 120.21,60.11
+3.3V_WLAN on TOP (solid shape): 71.85,118.76 71.85,117.98 70.58,116.71 67.53,116.71 67.53,117.72 67.66,117.85 68.55,117.85 69.57,118.87 70.52,118.87 70.71,119.06 71.55,119.06
+3.3V_WLAN on TOP (solid shape): 71.41,140.01 71.79,139.63 71.79,138.23 71.15,137.6 71.15,136.65 71.12,136.61 70.98,136.61 70.7,136.33 69.5,136.33 68.93,136.9 68.93,139.89 69.12,140.08 71.41,140.08
+3.3V_WLAN on BOTTOM (solid shape): 72.3,139.57 72.3,138.3 72.23,138.23 70.8,138.23 70.71,138.14 70.71,138.14 70.58,137.97 70.61,137.76 70.61,137.75 70.61,137.55 70.61,137.54 70.57,137.4 70.61,137.26 70.61,137.25 70.61,137.06 70.58,137.03 70.57,136.9 70.58,136.83 70.58,136.76 70.21,136.39 69.38,136.39 68.84,136.93 68.84,139.35 69.12,139.63 72.23,139.63
+3.3V_WLAN on BOTTOM (solid shape): 72.35,121.5 72.35,121.14 72.19,120.99 72.19,120.56 72.12,120.53 72.08,120.53 72.05,120.55 71.4,120.48 71.9,120.06 71.94,120.07 71.97,120.04 72.05,119.95 72.16,119.88 72.19,119.87 72.19,119.5 71.87,119.18 71.87,118.32 71.34,117.79 69.63,117.79 69.25,118.17 69.25,118.88 69.3,118.97 69.41,118.96 69.97,119.25 69.41,119.54 69.3,119.53 69.25,119.62 69.25,119.9 69.36,120.16 69.25,120.42 69.25,120.82 70.03,121.6 72.25,121.6
+3.3V_WLAN on IN2: 70.01,119.1 70.01,121.34 69.53,121.83 69.53,125.81 70.9,127.19 70.9,132.22 69.33,133.79 69.33,137.42 69.45,137.55 71.66,137.55 72.27,136.94 72.65,136.94 72.93,136.81 73.2,136.94 74.63,136.94 74.7,136.91 74.73,136.84 74.74,136.82 74.7,136.77 74.52,136.17 75.12,136.34 75.17,136.38 75.2,136.38 75.27,136.35 75.29,136.28 75.29,126.63 75.25,126.62 74.99,126.36 75.1,126 75.1,125.53 72.86,123.3 72.73,123.1 72.75,122.86 72.66,122.64 72.72,122.42 72.72,122.35 72.73,122.27 72.73,122.11 73.4,121.43 73.73,121.43 73.73,120.7 72.95,119.9 73.73,119.1 73.73,118.33 73.44,118.04 69.5,118.04 69.38,118.17 69.38,118.46
+3V_DVDD on TOP (solid shape): 38.69,15.86 38.69,15.26 38.64,15.21 38.43,15.21 38.01,14.79 38.01,14.05 35.16,14.05 35.01,13.9 33.82,13.9 33.76,13.95 33.76,14.08 33.82,14.13 34.64,14.13 35.3,14.79 36.98,14.79 37.27,15.07 37.27,15.55 37.68,15.96 38.58,15.96
+3V_DVDD on TOP (solid shape): 35.33,10.62 35.33,10.16 35.53,9.96 37.09,9.96 37.16,9.9 38.13,9.9 38.26,9.77 38.26,8.95 38.18,8.87 37.27,8.87 37.22,8.92 35.97,8.92 35.94,8.89 35.12,8.89 35.01,9 35.01,9.41 34.39,10.03 34.39,10.28 33.76,10.9 33.76,11.26 33.82,11.31 34.64,11.31
+3V_DVDD on IN1: 34.9,12.45 34.9,12 36.42,10.47 36.42,9.65 36.23,9.46 35.34,9.46 34.07,10.73 34.07,13.77 35.4,15.11 37.1,15.11 37.29,14.92 37.29,14.42 36.96,14.09 36.54,14.09
+3VALW on TOP (solid shape): 49.25,87.2 49.09,87.04 45.01,87.04 44.87,87.18 44.87,87.95 45.08,88.17 49.25,88.17
+3VALW on TOP (solid shape): 14.75,86.76 14.75,85.13 14.75,84.73 14.74,84.72 13.35,84.72 13.18,84.89 13.18,86.71 13.42,86.95 14.56,86.95
+3VALW on TOP (solid shape): 18.02,87.53 18.02,86.62 17.76,86.36 15.8,86.36 15.7,86.46 15.7,86.98 15.8,87.07 16.8,87.07 17.39,87.66 17.89,87.66
+3VALW on TOP (solid shape): 54.51,70.79 54.51,70.62 54.86,70.27 55.05,70.27 55.45,69.87 55.45,68.65 55.45,68.64 55.45,68.16 55.37,68.08 55.03,68.08 54.56,68.56 54.56,69.8 54.33,70.03 54.13,70.03 53.99,70.17 53.99,70.89 54.02,70.92 54.39,70.92
+3VALW on TOP (solid shape): 78.52,115.88 78.52,115.12 78.37,114.97 77.87,114.97 77.87,114.96 76.81,114.96 76.13,114.29 75.83,114.29 75.83,114.8 75.39,114.8 75.39,114.29 74.62,114.29 74.49,114.42 74.49,115.76 74.99,116.26 78.14,116.26
+3VALW on TOP (solid shape): 208.44,56.38 208.44,55.93 208.24,55.72 208.24,55.35 207.81,54.92 206.73,54.92 206.73,55.49 206.22,55.49 206.22,54.92 205.52,54.92 205.33,54.73 205.33,54.1 205.27,54.03 204.57,54.03 204.44,54.16 204.44,56.19 204.76,56.51 208.31,56.51
+3VALW on TOP (solid shape): 70.1,33.07 70.1,31.44 69.85,31.19 69.5,31.19 69.14,31.25 68.91,30.97 68.9,30.92 68.19,30.92 67.64,31.48 67.64,32.79 67.83,32.98 69.16,32.98 69.33,33.15 70.01,33.15
+3VALW on TOP (solid shape): outline of 258 points within 31.72,53.27 47.21,64.09
+3VALW on BOTTOM (solid shape): 208.5,56.26 208.5,55.56 208.31,55.37 205.84,55.37 205.71,55.49 205.71,56.32 205.77,56.38 208.38,56.38
+3VALW on BOTTOM (solid shape): 29.95,58.14 30.03,58.09 30.05,58 30.04,57.83 30.11,57.67 30.14,57.61 30.11,57.54 30.39,56.96 30.66,57.54 30.64,57.61 30.66,57.67 30.67,57.69 30.75,57.73 30.83,57.7 31.17,57.35 32.29,57.35 33.98,55.66 33.98,53.34 33.59,52.94 30.9,52.94 30.89,52.95 30.2,52.95 28.85,54.3 28.85,55.39 29.37,55.39 29.37,56.1 28.85,56.1 28.85,56.59 29.37,56.59 29.37,57.3 28.85,57.3 28.85,57.87 29.12,58.14
+3VALW on IN1: 13.49,85.11 18.19,85.11 18.87,85.78 18.87,87.33 18.44,87.76 13.68,87.76 13.24,87.33 13.24,85.35
+3VALW on VCC: outline of 96 points within 14.26,20.63 227.23,137.98
+3VALW_1.8V on TOP (solid shape): 207.3,54.54 207.3,53.34 207.17,53.21 205.65,53.21 205.52,53.34 205.52,54.54 205.71,54.73 207.11,54.73
+3VALW_1.8V on BOTTOM (solid shape): 207.3,54.92 207.3,53.34 206.09,52.13 204.31,52.13 204,52.45 204,54.99 204.06,55.05 207.17,55.05
+3VALW_2.5V on TOP (solid shape): 76.13,114.11 76.13,113.08 75.95,112.9 73.01,112.9 72.67,112.56 70.76,112.56 70.57,112.75 70.57,113.13 70.77,113.33 72.21,113.33 73,114.12 76.12,114.12
+3VALW_DSW on BOTTOM (solid shape): 109.03,58.92 109.03,58.29 109.16,58.16 111.09,58.16 111.14,58.11 111.14,56.06 111.08,56 109.22,56 108.99,56.24 108.99,57.41 108.8,57.6 108.23,57.6 107.99,57.84 107.99,58.94 108.01,58.96 109,58.96
+3VALW_DSW on BOTTOM (solid shape): 122.53,59.78 122.53,59.77 122.59,59.69 122.66,59.64 122.67,59.63 123.11,59.2 123.28,59.2 123.38,59.1 123.42,59.05 123.46,59.01 123.46,58.78 123.42,58.74 123.38,58.68 123.31,58.62 123.08,58.62 123.07,58.63 123.02,58.63 123,58.66 122.92,58.77 122.79,58.83 122.77,58.83 122.17,59.43 122.08,59.43 122.06,59.44 121.87,59.47 121.71,59.35 121.71,59.35 121.63,59.28 121.35,59.28 121.33,59.3 121.3,59.37 121.25,59.41 121.25,59.68 121.3,59.73 121.33,59.8 121.34,59.83 121.61,59.83 121.68,59.91 121.75,59.96 121.8,60.02 121.81,60.04 122.27,60.04
+3VALW_DSW on IN1: 121.23,59.86 122.88,59.86 123.51,59.22 123.51,58.59 123.39,58.46 122.62,58.46 121.86,59.22 121.23,59.22 121.1,59.35 121.1,59.73
+3VALW_EC on TOP (solid shape): 54.25,85.96 54.25,85.41 53.9,85.05 53.9,82.34 53.75,82.19 52.88,82.19 52.52,82.55 49.69,82.55 49.64,82.61 49.64,84.24 49.71,84.31 49.72,84.31 50.03,84.62 52.42,84.62 53.12,85.32 53.12,86.02 53.17,86.06 54.15,86.06
+3VALW_PCH on TOP (solid shape): 53.88,99.75 53.88,98.74 53.25,98.1 50.71,98.1 50.71,98.99 51.85,100.13 53.5,100.13
+3VALW_PCH on TOP (solid shape): 46.64,120.84 46.64,119.18 46.14,118.68 45.37,118.68 44.99,119.06 44.99,120.84 45.25,121.09 46.39,121.09
+3VALW_PCH on TOP (solid shape): 68.3,139.76 68.3,139 68.17,138.87 66.77,138.87 66.65,139 66.65,139.7 66.84,139.89 68.17,139.89
+3VALW_PCH on TOP (solid shape): 60.17,134.62 60.17,133.28 59.98,133.09 59.52,133.09 59.42,133.11 59.32,133.09 59.09,133.09 58.96,133.22 58.96,134.55 59.09,134.68 60.11,134.68
+3VALW_PCH on TOP (solid shape): 73.19,38.86 73.19,38.1 73.12,38.03 72.3,38.03 71.6,37.33 71.15,37.33 71.15,37.9 69.76,37.9 69.76,37.33 69.31,37.33 69.19,37.46 69.19,38.79 69.5,39.11 72.93,39.11
+3VALW_PCH on TOP (solid shape): 126.93,45.55 126.91,45.52 126.91,45.21 126.72,45.02 126.72,44.06 126.78,44 128.19,44 128.22,43.98 128.22,43.34 128.3,43.26 129.79,43.26 129.9,43.15 129.9,42.29 129.8,42.19 129.56,42.19 129.53,42.2 129.47,42.2 129.44,42.19 127.17,42.19 126.84,42.53 126.84,42.73 127.97,42.73 127.97,42.68 127.98,42.63 128,42.58 128.02,42.53 128.05,42.48 128.09,42.44 128.13,42.41 128.17,42.38 128.22,42.36 128.28,42.35 128.33,42.35 128.38,42.35 128.43,42.36 128.48,42.38 128.53,42.41 128.57,42.44 128.61,42.48 128.64,42.53 128.66,42.58 128.68,42.63 128.69,42.68 128.69,42.73 128.68,42.78 128.66,42.84 128.64,42.88 128.61,42.93 128.57,42.97 128.53,43 128.48,43.03 128.43,43.05 128.38,43.06 128.33,43.06 128.28,43.06 128.22,43.05 128.17,43.03 128.13,43 128.09,42.97 128.05,42.93 128.02,42.88 128,42.84 127.98,42.78 127.97,42.73 126.84,42.73 126.84,42.95 126.08,43.71 126.08,44.63 126.04,44.67 126.04,44.71 126,44.71 125.82,44.89 124.81,44.89 124.59,45.11 124.59,45.54 124.79,45.74 126.74,45.74
+3VALW_PCH on BOTTOM (solid shape): 95.33,46.24 95.33,45.19 94.78,44.64 93.63,44.64 93.51,44.76 93.51,45.4 94.52,46.41 95.16,46.41
+3VALW_PCH on BOTTOM (solid shape): 71.98,39.05 71.98,38.35 71.79,38.16 69.94,38.16 69.55,38.54 69.55,38.94 69.79,39.17 71.85,39.17
+3VALW_PCH on IN2 (solid shape): 47.41,121.72 47.41,121.09 46.14,119.82 45.25,119.82 44.99,120.07 44.99,120.84 46.26,122.11 47.02,122.11
+3VALW_PCH on IN2 (solid shape): 54.64,99.88 54.64,97.98 54.39,97.72 53.76,97.72 52.87,98.61 52.87,99.88 53.12,100.13 54.39,100.13
+3VALW_PCH on IN2 (solid shape): 60.49,133.66 60.49,132.77 59.22,131.5 58.58,131.5 58.33,131.76 58.33,133.41 58.84,133.92 60.23,133.92
+3VALW_PCH on IN2 (solid shape): 56.68,57.21 57.18,57.21 57.57,56.83 57.57,55.43 57.31,55.18 57.18,55.18 56.93,55.28 56.68,55.18 55.79,55.18 55.53,55.43 55.53,57.46 55.79,57.72 56.17,57.72
+3VALW_PCH on IN2 (solid shape): 130.34,43.32 130.3,43.29 130.2,43.04 130.29,42.79 130.32,42.72 130.3,42.66 130.21,42.43 130.32,42.13 130.29,42.07 130.22,41.76 130.41,41.52 130.44,41.5 130.44,41.41 129.98,40.95 129.47,40.95 129.19,41.23 129.19,41.66 129.86,41.84 129.19,42.02 129.19,43.29 129.31,43.4 130.26,43.4
+3VALW_PCH on IN3 (solid shape): 57.44,56.95 57.44,55.56 57.31,55.43 55.79,55.43 55.66,55.56 55.66,56.45 56.42,57.21 57.18,57.21
+3VALW_PCH on IN3 (solid shape): 70.96,39.37 70.96,38.67 70.84,38.54 68.87,38.54 68.68,38.73 68.68,39.37 68.93,39.62 70.71,39.62
+3VALW_PCH on IN1: 117.93,40.37 117.78,40.51 117.78,46.33 113.64,50.48 112.3,50.48 109.13,47.3 101,47.3 98.46,44.76 95.03,44.76 94.78,45.02 94.78,46.54 95.03,46.79 96.81,46.79 101.51,51.49 104.43,51.49 107.98,55.05 109.64,55.05 110.4,55.81 112.68,55.81 113.81,56.94 122.62,56.94 122.88,57.19 123.59,57.19 123.73,57.34 123.73,59.88 122.72,60.89 122.72,61.65 122.84,61.78 126.65,61.78 128.05,60.38 128.05,54.54 126.36,52.86 125.83,52.86 125.16,52.19 125.16,52.17 125.15,52.12 125.12,52.07 125.09,51.99 125.14,51.91 125.23,51.86 125.29,51.78 125.26,51.75 123.61,51.75 122.34,50.48 122.34,48.97 121.16,47.79 121.16,45.95 120.33,45.12 120.33,40.71 119.99,40.37
+3VALW_PCH_OUT on TOP (solid shape): 70.98,37.72 70.98,37.2 71.01,37.18 71.49,37.18 71.66,37.01 71.66,36.27 71.14,35.75 70.54,35.75 70.1,35.31 70.1,34.63 70.01,34.54 68.93,34.54 68.61,34.86 68.61,36.95 68.84,37.18 69.91,37.18 69.93,37.19 69.93,37.72 69.93,37.72 70.18,37.72 70.18,37.72 70.18,37.18 70.19,37.17 70.73,37.17 70.73,37.18 70.73,37.7 70.75,37.73 70.97,37.73
+3VALWP on TOP (solid shape): 27.93,53.54 27.93,50.7 27.64,50.41 24.32,50.41 24.1,50.63 24.1,54.29 24.16,54.35 27.12,54.35
+3VALWP on BOTTOM (solid shape): 28.72,57.84 28.72,57.19 28.72,57.19 28.72,57.17 29.21,57.17 29.21,56.72 28.72,56.72 28.72,56.7 28.72,56.7 28.72,55.99 28.72,55.99 28.72,55.97 29.21,55.97 29.21,55.52 28.72,55.52 28.7,55.52 28.69,55.51 28.69,54.15 28.14,53.6 28.14,47.52 27.84,47.21 24.38,47.21 24.11,47.48 24.11,57.4 24.58,57.87 28.69,57.87
+3VGS on BOTTOM (solid shape): 130.9,116.08 130.9,115.93 130.89,115.91 130.89,115.59 130.87,115.57 130.38,115.57 130.36,115.57 130.36,115.55 130.34,115.54 130.34,115.09 130.36,115.08 130.36,115.06 130.37,115.06 130.38,115.05 130.81,115.05 130.88,115.05 130.89,115.04 130.89,114.79 130.88,114.78 130.39,114.78 130.38,114.77 130.36,114.77 130.35,114.74 130.35,114.3 130.36,114.3 130.36,114.26 130.39,114.26 130.41,114.24 130.89,114.24 130.9,114.24 130.9,113.78 130.59,113.47 130.06,113.47 126.97,113.47 126.72,113.72 126.72,114.55 126.7,114.55 126.7,115.33 126.97,115.61 128.49,115.61 129.15,116.26 130.72,116.26
+3VGS_OUT on BOTTOM (solid shape): 132.44,117.79 132.75,117.33 133.05,117.79 133.37,117.79 133.75,117.41 133.75,116.33 133.7,116.27 132.73,116.27 132.53,116.06 132.52,116.06 132.01,115.56 132.01,114.59 132.02,114.58 132.02,114.13 131.73,113.84 131.07,113.84 131.03,113.88 131.03,114.37 131.02,114.38 130.49,114.38 130.48,114.39 130.48,114.64 130.49,114.65 131.01,114.65 131.03,114.66 131.03,115.18 131.02,115.18 130.49,115.18 130.48,115.19 130.48,115.44 130.48,115.44 131.02,115.44 131.03,115.45 131.03,117.59 131.23,117.79
+3VLP on BOTTOM (solid shape): 21.93,45.33 21.93,45.04 21.87,44.98 21.87,43.39 21.84,43.37 21.03,43.37 20.96,43.43 20.96,44.08 21.02,44.17 21.04,44.27 21.04,44.9 21.02,45.01 20.96,45.09 20.96,45.24 21.12,45.4 21.87,45.4
+3VS on TOP (solid shape): 64.93,44.51 64.93,43.49 64.8,43.37 63.28,43.37 63.15,43.49 63.15,44.51 63.2,44.56 64.88,44.56
+3VS on TOP (solid shape): 30.32,32.25 30.32,30.6 29.5,29.78 26.07,29.78 25.94,29.9 25.94,31.17 27.47,32.7 29.88,32.7
+3VS on TOP (solid shape): 67.34,119.06 67.34,116.9 67.09,116.64 66.2,116.64 66.07,116.77 66.07,119.18 66.2,119.31 67.09,119.31
+3VS on TOP (solid shape): 39.72,18.92 39.72,15.39 39.51,15.18 39,15.18 38.98,15.2 38.98,15.99 38.12,16.85 38.12,18.99 38.32,19.19 39.45,19.19
+3VS on TOP (solid shape): 217.01,32.44 218.31,32.44 218.57,32.18 218.86,32.18 218.98,32.07 218.98,31.68 218.85,31.55 214.63,31.55 214.36,31.83 214.36,32.61 214.47,32.72 216.74,32.72
+3VS on TOP (solid shape): 40.35,57.2 40.37,57.2 40.55,57.02 42.57,57.02 42.66,56.93 42.66,54.71 42.52,54.57 40.1,54.57 39.69,54.98 39.69,56.48 39.54,56.63 39.54,57.28 39.6,57.34 40.21,57.34
+3VS on TOP (solid shape): 77.6,43.9 77.6,43.04 77.35,42.8 77.14,42.8 77.01,42.92 77,42.96 77,43.11 76.87,43.24 75.85,43.24 75.6,43.49 75.6,44 75.65,44.05 77.45,44.05
+3VS on TOP (solid shape): 83.29,37.78 83.29,37.17 83.48,36.97 83.48,36.65 83.17,36.34 83.17,35.89 83.14,35.86 82.67,35.86 82.61,35.93 82.61,37.79 82.71,37.89 83.18,37.89
+3VS on TOP (solid shape): 171.43,29.04 171.43,28.38 171.08,28.04 170.56,28.04 170.47,28.13 170.47,28.46 170.66,28.66 170.66,28.85 170.66,28.93 170.63,29.01 170.62,29.04 170.72,29.14 171.33,29.14
+3VS on TOP (solid shape): 221.78,59.49 221.78,58.86 221.52,58.61 221.52,57.92 221.53,57.92 221.53,57.09 221.31,56.87 219.88,56.87 219.64,57.11 219.64,59.28 219.98,59.62 221.65,59.62
+3VS on TOP (solid shape): 171.05,33.15 171.05,31.22 170.89,31.06 170.89,30.19 170.84,30.14 170.61,30.14 170.53,30.22 168.95,30.22 168.85,30.32 168.85,31.71 168.97,31.82 169.43,31.82 169.59,31.99 169.68,31.99 169.68,32.07 169.98,32.37 169.98,33.09 170.18,33.3 170.9,33.3
+3VS on BOTTOM (solid shape): 137.96,117.2 137.96,116.7 137.81,116.55 137.18,116.55 137.04,116.4 136.19,116.4 136.06,116.27 135.17,116.27 135.11,116.33 135.11,116.96 135.39,117.24 137.92,117.24
+3VS on BOTTOM (solid shape): 202.35,39.05 202.35,38.54 202.6,38.29 202.6,36.25 202.47,36.13 201.96,36.13 201.84,36.25 201.84,37.52 201.71,37.65 201.08,37.65 200.69,38.03 200.69,39.05 200.82,39.17 202.22,39.17
+3VS on VCC: 30.87,29.78 28.36,32.3 28.36,37.8 34.71,44.15 34.71,57.08 39.13,57.08 40.04,57.99 40.04,111.71 48.15,119.82 80.7,119.82 82.86,117.66 88.83,117.66 90.59,115.9 90.59,112.83 59.73,112.83 56.14,109.24 56.14,73.77 57.31,72.6 57.31,71.92 56.14,70.74 56.14,47.87 60,44 90.06,44 94.63,48.57 99.58,48.57 100.22,49.21 115.63,49.21 122.61,42.22 147.46,42.22 148.12,42.88 148.12,43.64 148.6,44.13 152.43,44.13 152.43,39.58 153.47,38.54 190.94,38.54 191.95,37.52 195.08,37.52 196.5,38.94 196.5,47.39 199.59,50.48 209.69,50.48 210.85,51.64 210.85,54.8 215.28,54.8 220.36,59.88 221.29,59.88 221.78,59.39 221.78,55.66 219.11,53 219.11,44.23 209.61,34.73 173.79,34.73 170.24,31.17 149.62,31.17 146.82,33.97 126.5,33.97 125.49,34.98 121.72,34.98 120.71,33.97 53.52,33.97 49.33,29.78 ; 1 cut-out
+3VS_SSD on TOP (solid shape): outline of 131 points within 22.83,25.31 28.23,29.14
+3VS_SSD on BOTTOM (solid shape): outline of 1080 points within 20.95,21.14 39.72,31.1
+5V_AVDD on TOP (solid shape): 28.45,20.36 28.49,20.27 28.56,20.2 28.56,17.33 29.95,15.93 29.95,15.17 29.9,15.12 29.34,15.12 27.44,17.03 27.44,19.36 27.26,19.54 26.59,19.54 26.39,19.74 26.39,20.49 28.32,20.49
+5V_HDD on TOP (solid shape): 185.33,36.76 185.33,34.34 184.92,34.28 184.85,33.87 184.31,33.33 183.3,33.33 183.04,33.59 183.04,36.63 183.41,37 185.09,37
+5V_HDD on BOTTOM (solid shape): 185.5,37.17 185.5,36.55 185.85,36.19 185.85,35.13 185.77,35.04 183.87,35.04 183.33,35.57 183.33,37.54 183.51,37.72 184.94,37.72
+5V_HDMI on TOP (solid shape): 17.24,101.85 17.24,100.77 17.12,100.64 15.91,100.64 15.02,99.75 14.58,99.75 14.39,99.94 14.39,101.6 14.45,101.66 15.15,101.66 15.4,101.91 17.18,101.91
+5V_HDMI on IN1 (solid shape): 15.02,101.53 15.02,99.59 14.84,99.41 13.9,99.41 12.9,100.41 12.32,100.41 12.14,100.59 12.14,101.44 12.35,101.66 14.89,101.66
+5V_KB_BL on BOTTOM (solid shape): 100.05,36.58 100.05,34.73 99.86,34.54 98.65,34.54 98.14,34.03 94.9,34.03 94.82,34.11 94.82,34.82 94.89,34.89 94.95,34.92 94.99,34.95 95.19,34.95 95.28,34.86 95.47,34.86 95.54,34.85 95.6,34.86 95.92,34.86 96.36,35.3 97.38,35.3 97.6,35.52 97.6,36.44 97.6,36.44 97.6,36.71 97.76,36.87 99.76,36.87
+5V_PVDD on TOP (solid shape): 31.17,10.85 31.17,10.02 31.22,9.96 31.22,9.66 30.82,9.25 30.82,8.12 31.01,7.93 33.43,7.93 33.71,8.21 33.71,9.18 32.95,9.94 32.95,10.85 33,10.9 33.1,10.9 33.15,10.85 33.15,10.09 33.36,9.89 33.69,9.89 34.12,9.46 34.12,8.76 34.82,8.06 36.23,8.06 36.36,7.93 36.67,7.93 36.67,6.54 35.85,6.54 35.53,6.85 30.64,6.85 30.45,7.04 30.45,7.74 30.45,9.32 30.95,9.81 30.95,10.83 31.02,10.9 31.12,10.9
+5VALW on TOP (solid shape): 206.66,34.98 206.66,32.57 206.41,32.32 205.39,32.32 204.89,32.82 204.89,35.11 205.01,35.24 206.41,35.24
+5VALW on TOP (solid shape): 193.96,38.79 193.96,36.25 193.58,35.87 192.31,35.87 191.68,36.51 191.68,38.92 191.93,39.17 193.58,39.17
+5VALW on TOP (solid shape): 200.5,33.84 200.5,33.02 200.19,32.7 197.52,32.7 197.14,33.08 197.14,34.48 197.39,34.73 199.61,34.73
+5VALW on TOP (solid shape): 71.24,32.99 71.39,32.84 72.67,32.84 72.67,32.38 71.98,31.68 70.95,31.68 70.82,31.82 70.82,33.16 70.86,33.2 71.03,33.2
+5VALW on TOP (solid shape): 95.47,60.96 95.47,60.7 95.35,60.57 94.33,60.57 94.11,60.36 94.09,60.33 94.07,60.31 93.57,59.81 93.32,59.81 93.19,59.94 93.19,60.89 93.32,61.02 95.41,61.02
+5VALW on TOP (solid shape): 34.41,23.33 34.25,23.16 34.04,23.1 33.93,22.92 32.48,22.92 32.29,23.11 32.29,24.25 34.41,24.25
+5VALW on TOP (solid shape): 29.66,112.53 29.66,109.72 29.4,109.46 27.86,109.46 27.86,109.98 27.35,109.98 27.35,109.46 27.06,109.46 27.06,109.98 26.55,109.98 26.55,109.46 25.27,109.46 25.15,109.58 25.15,111.99 25.54,112.38 25.99,112.83 29.36,112.83
+5VALW on TOP (solid shape): 37.89,60.05 37.89,59.74 38.26,59.37 38.26,58.86 38.2,58.8 36.61,58.8 36.1,58.29 35.72,58.29 35.59,58.42 35.59,58.67 35.47,58.8 35.02,58.8 34.96,58.86 34.96,60.51 35.13,60.68 37.26,60.68
+5VALW on BOTTOM (solid shape): 169.83,52.19 169.83,50.73 170.02,50.54 171.29,50.54 171.36,50.48 171.36,49.97 171.29,49.91 169.45,49.91 168.77,50.59 168.77,52.4 168.88,52.51 169.52,52.51
+5VALW on BOTTOM (solid shape): 19.4,50.57 19.4,48.74 18.22,47.56 17.62,47.56 17.12,47.05 15.67,47.05 15.02,47.7 15.02,48.51 15.4,48.89 16.12,48.89 16.61,49.37 16.61,50.3 16.95,50.64 19.32,50.64
+5VALW on BOTTOM (solid shape): 29.56,112.83 29.56,109.77 29.28,109.49 28.18,109.49 27.86,109.49 27.86,110.02 27.35,110.02 27.35,109.49 27.06,109.49 27.06,110.02 26.55,110.02 26.55,109.49 25.45,109.49 25.34,109.6 25.34,112.29 25.94,112.9 29.5,112.9
+5VALW on BOTTOM (solid shape): 136.32,115.38 136.32,114.85 136.52,114.65 137.03,114.65 137.46,114.22 137.4,114.06 137.44,113.9 137.44,113.67 137.29,113.53 135.92,113.53 135.47,113.98 135.47,114.84 135.09,115.22 135.09,115.49 135.15,115.55 136.14,115.55
+5VALW on BOTTOM (solid shape): 203.01,34.71 203.01,34.37 203.01,34.2 203.21,33.99 203.51,33.99 203.72,34.2 203.72,34.37 203.72,34.71 203.72,34.73 206.54,34.73 206.68,34.59 206.68,32.58 206.41,32.32 199.04,32.32 198.79,32.57 198.79,32.95 200.78,32.95 200.79,32.9 200.8,32.85 200.82,32.8 200.84,32.75 200.88,32.71 200.92,32.67 200.96,32.64 201.01,32.62 201.06,32.6 201.11,32.6 201.17,32.6 201.22,32.6 201.27,32.62 201.32,32.64 201.36,32.67 201.4,32.71 201.43,32.75 201.46,32.8 201.48,32.85 201.49,32.9 201.5,32.95 201.49,33.01 201.48,33.06 201.46,33.11 201.43,33.15 201.4,33.19 201.36,33.23 201.32,33.26 201.27,33.28 201.22,33.3 201.17,33.31 201.11,33.31 201.06,33.3 201.01,33.28 200.96,33.26 200.92,33.23 200.88,33.19 200.84,33.15 200.82,33.11 200.8,33.06 200.79,33.01 200.78,32.95 198.79,32.95 198.79,34.48 199.04,34.73 203,34.73
+5VALW on VCC: 192.16,38.03 191.15,39.05 153.68,39.05 152.94,39.79 152.94,44.13 154.44,44.13 155.36,45.04 155.36,48.34 159.17,52.15 159.17,66.25 161.07,68.15 161.07,85.89 155.86,91.1 155.86,105.19 152.79,108.26 132.35,108.26 129.17,111.44 120.45,111.44 119.67,110.65 119.67,108.26 95.52,108.26 91.09,112.69 91.09,116.12 89.04,118.17 83.07,118.17 80.91,120.33 47.93,120.33 39.53,111.92 39.53,58.2 38.92,57.59 30.87,57.59 27.97,60.49 27.97,106.84 25.82,109 25.82,117.3 36.08,127.57 96.17,127.57 96.17,123.52 100.66,119.04 144.22,119.04 148.65,114.61 160.69,114.61 160.69,101.53 161.65,100.57 168.36,93.58 168.64,93.3 168.64,89.06 169.2,88.5 169.2,82.86 170.11,81.94 170.11,77.47 181.39,66.2 181.39,59.26 185.2,55.45 185.2,52.49 184.08,51.37 180.14,51.37 179.13,50.35 172.61,50.35 170.72,52.23 170.72,56.93 170.07,57.59 167.19,57.59 166.53,56.93 166.53,50.33 165.26,49.06 165.26,43.77 166.3,42.73 195.51,42.73 196,42.24 196,39.15 194.87,38.03 ; 1 cut-out
+5VALW on IN2: 37.61,60.42 37.61,58.03 37.18,57.6 35.91,56.32 35.91,53.65 34.35,52.1 34.35,40.32 31.02,36.98 24.2,36.98 22.7,38.48 22.7,40.55 23.53,41.37 28.39,41.37 29.89,42.87 29.89,58.22 31.38,59.7 31.38,60.09 32.17,60.87 37.16,60.87
+5VALW on IN3: 21.14,38.03 18.44,40.73 18.41,41.2 17.94,41.23 15.4,43.77 15.4,44.7 15.41,44.71 15.41,46.31 15.19,46.53 15.19,47.57 14.98,47.77 15.02,47.81 15.02,48.7 15.29,48.97 18.13,48.97 18.6,48.51 18.6,46.12 18,45.52 18,44.95 19.65,43.31 19.63,43.28 19.64,42.78 20.13,42.78 20.17,42.79 20.2,42.78 22.06,40.92 23.93,40.92 24.37,40.49 24.37,38.5 23.9,38.03 23.05,38.03 22.7,38.32 22.35,38.03
+5VALW_25810 on BOTTOM (solid shape): 30.63,116.27 30.63,115.37 31.01,114.99 32.69,114.99 32.7,114.99 32.81,114.97 32.92,114.99 32.93,114.99 34.38,114.99 34.38,114.99 34.51,114.86 34.51,113.32 34.28,113.09 28.8,113.09 28.48,113.41 28.48,114.1 28.46,114.12 27.78,114.12 27.62,114.28 27.62,114.9 27.64,114.92 27.65,114.92 27.95,115.22 28.42,115.22 28.44,115.24 28.73,115.24 28.86,115.37 28.86,116.26 28.99,116.39 30.5,116.39
+5VALWP on TOP (solid shape): 26.93,109.33 26.95,109.33 27.46,109.33 27.48,109.33 27.48,109.85 27.72,109.85 27.73,109.84 27.73,109.33 27.75,109.33 28.24,109.33 28.26,109.31 28.79,109.31 28.82,109.28 28.86,109.28 28.99,109.15 28.99,109.11 29.02,109.08 29.02,107.06 28.29,106.33 23.53,106.33 23.12,105.92 23.12,104.06 23.42,103.75 23.91,103.75 23.97,103.69 23.97,102.59 23.85,102.46 23.12,102.46 23.11,102.47 23,102.49 22.88,102.47 22.87,102.46 22.09,102.46 21.08,103.47 16.94,103.47 16.73,103.67 16.73,107.15 17.21,107.63 20.29,107.63 21.99,109.33 26.66,109.33 26.68,109.33 26.68,109.85 26.93,109.85
+5VALWP on BOTTOM (solid shape): 28.99,109.15 28.99,106.93 28.39,106.33 23.61,106.33 23.12,105.83 23.12,104.05 22.32,103.25 21.3,103.25 21.08,103.47 16.95,103.47 16.73,103.69 16.73,107.63 17.13,108.03 17.17,108.01 20.01,107.59 22.34,109.28 28.86,109.28
+5VS on TOP (solid shape): 64.49,25.33 64.49,24.13 64.04,23.68 58.31,23.68 58.18,23.81 58.18,25.71 64.11,25.71
+5VS on TOP (solid shape): 39.59,7.74 39.59,6.6 39.47,6.47 37.56,6.47 37.56,7.87 39.47,7.87
+5VS on TOP (solid shape): 182.28,34.86 182.28,30.47 181.72,29.9 181.14,29.9 180.25,30.79 180.25,34.86 180.5,35.11 182.03,35.11
+5VS on TOP (solid shape): 185.58,70.41 185.58,69.7 185.28,69.4 183.3,69.4 183.17,69.53 183.17,70.67 183.55,71.05 184.94,71.05
+5VS on TOP (solid shape): 219.17,30.41 219.17,28.95 218.98,28.76 218.28,28.76 217.08,29.97 217.08,31.29 217.2,31.42 218.16,31.42
+5VS on TOP (solid shape): 27.47,22.28 27.47,21.33 27.34,21.2 26.39,21.2 26.26,21.33 26.26,22.35 26.39,22.47 27.28,22.47
+5VS on TOP (solid shape): 196,66.99 196,64.38 195.55,63.94 193.14,63.94 192.66,64.42 192.66,67.05 192.78,67.18 195.8,67.18
+5VS on TOP (solid shape): 214.22,32.67 214.22,31.25 214.17,31.2 213.18,31.2 213.1,31.28 213.1,32.29 213.1,32.34 213.1,32.4 213.1,32.69 213.17,32.76 214.13,32.76
+5VS on TOP (solid shape): 42.96,60.38 42.96,59.9 42.96,58.89 42.43,58.35 41.11,58.35 40.72,58.73 39.59,58.73 39.52,58.8 39.52,59.46 39.35,59.46 38.84,59.97 38.84,60.75 38.86,60.76 42.58,60.76
+5VS on TOP (solid shape): outline of 333 points within 127.03,24.57 151.67,33.46
+5VS on BOTTOM (solid shape): 185.45,70.92 185.45,69.78 185.2,69.53 181.64,69.53 180.69,70.48 180.69,70.86 180.88,71.05 185.33,71.05
