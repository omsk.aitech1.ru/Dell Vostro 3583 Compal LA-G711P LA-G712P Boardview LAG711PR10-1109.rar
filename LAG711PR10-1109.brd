# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8VALW_EC: length 4
  TOP w0.203: CE13.1 53.76,78.16 53.25,77.66 52.49,77.66 52.33,77.81 UE1.54
  TOP w0.508: RE7.2 53.95,78.15 CE13.1
+1.8VALWP: length 12.9
  TOP w0.127: PC1802.1 v2(197.07,61.83)
  BOTTOM w0.254: PC1804.1 197.07,62.42 197.33,62.67 200.76,62.67 204.5,58.92 PC1807.1 PR1807.1
  vias: v1(196.25,60.76) v1(196.25,60.13)
+1.8VGS: length 94.7
  TOP w0.112: LV6.1 126.04,123.23 v1(126.04,122.36)
  TOP w0.203: v1(68.36,131.67) 68.2,131.67 67.84,131.3 PRV12.1
  TOP w0.381: 111.88,135.6 110.44,135.6 110.11,135.28 ; 111.88,135.6 111.88,135.62 112.87,136.61 RV11.1 ; 111.88,135.6 112.68,134.81 RV13.1
  TOP w0.508: RV8.1 115.81,134.15 v1(115.81,133.54) ; LV7.1 131.1,119.31 v1(132.75,117.66)
  IN1 w0.254: v1(68.36,131.67) 68.83,132.13 76.99,132.13 79.51,134.66 81.69,134.66 82.07,134.28 85.39,134.28 88.95,137.84 91.68,137.84 95.1,141.26 98.46,141.26 106.82,132.9 108.29,132.9 v1(108.73,132.47)
  IN2 w0.508: v1(132.75,117.66) 131.81,117.66 127.12,122.36 v1(126.04,122.36) 125.96,122.36 123.73,120.13 123.02,120.13 v1(120.81,117.91) 117.19,117.91 v1(115.29,119.82)
  BOTTOM w0.254: UV1.AM30 113.33,143.01 v1(113.33,142.98) ; v1(115.81,133.54) 115.68,133.41 112.48,133.41 111.53,132.46 108.74,132.46 v1(108.73,132.47)
  BOTTOM w0.508: v1(120.81,117.91) 120.62,118.11 RV81.2 RV82.2 ; v1(110.27,122.49) 110.27,123.38 109.71,123.93 RV25.1
  vias: v1(113.38,119.82) v1(114.02,119.82) v1(114.65,119.82) v3(114.91,120.56)
+1.8VGS_GPU_ON: length 3.2
  BOTTOM w0.112: UZ6.5 118.63,109.01 v2(118.15,108.52) 117.89,108.26 CZ33.2 RZ7.2
+1.8VGS_OUT:
  vias: v2(115.71,111.45)
+1.35V_MEM_GFX: length 57.4
  TOP w0.356: CV156.1 CV154.1 156.79,135.75 v1(156.83,135.78) ; v1(157.07,130.15) 157.16,130.23 CV177.1 ; CV175.1 152.39,128.43 v1(152.31,128.51) ; CV180.1 152.6,130.2 v1(152.69,130.29) ; v1(153.51,130.23) 153.6,130.14 CV176.1 ; CV174.1 149.17,116.64 148.88,116.94 v1(148.88,117.72)
  TOP w0.508: v1(157.62,132.53) 157.22,132.93 RV86.1 RV85.1 ; 162.72,143.95 162.47,143.7 162.47,141.66 ; v1(160.31,147.13) 160.31,147.71 160.3,147.72 CV167.1 ; CV168.1 159.34,147.3 v1(159.51,147.13) ; CV169.1 156.59,149.32 155.94,149.96 RV79.1 RV78.1 154.13,149.96 153.62,149.46 v1(153.62,148.36) ; RV52.1 v1(163.32,146.24)
  BOTTOM w0.254: UV15.L13 v1(153.9,128.51) UV15.K12 ; v1(152.31,126.88) 151.93,126.51 UV15.N10 ; UV15.C5 v1(160.32,122.92) ; UV13.P12 151.11,145.13 150.71,145.52 v1(150.71,145.54) ; v1(149.87,123) 150.31,122.56 UV15.R5 ; UV15.G1 v1(156.71,118.74) ; UV15.D11 159.11,127.32 v1(159.5,127.71) UV15.D12 ; UV15.C10 v1(159.51,126.11) ; UV15.K3 v1(154.75,121.35) ; v1(161.08,130.79) 160.71,130.43 UV15.B14 ; UV15.L14 153.51,130.23 v1(153.51,130.23) ; UV15.D14 159.11,130.27 v1(159.15,130.3) ; UV13.M12 v1(152.31,144.73) ; 151.11,137.93 UV13.P3 ; UV15.F14 v1(157.07,130.15) 156.71,129.79 UV15.G14 ; UV15.P11 151.11,127.28 v1(150.7,126.88) 150.33,126.51 UV15.R10 ; UV15.H12 155.91,128.07 v1(156.3,127.68) 156.67,127.31 UV15.G11 ; v1(130.99,133.53) 130.99,133.17 130.61,132.8 UV1.H16 ; UV15.H3 UV15.G2 v1(156.31,119.71) ; v1(150.71,127.71) UV15.P12 151.11,128.11 v1(150.71,128.51) ; UV15.E10 v1(157.95,126.14) ; UV15.E5 v1(157.95,122.87) ; UV15.D1 v1(159.11,118.79) ; UV15.T14 v1(149.05,130.17) ; UV15.T3 v1(149.09,120.49) ; v1(152.27,122.98) 152.27,122.94 151.91,122.58 UV15.N5 ; v1(151.11,147.24) 151.11,147.24 UV13.P14 ; v1(149.91,128.51) 149.51,128.11 UV15.T12 ; 152.71,136.33 UV13.M1 ; v1(157.13,120.52) UV15.F3 ; v1(149.92,144.73) 149.52,145.13 UV13.T12 ; v1(152.7,147.23) 152.71,147.22 UV13.M14 ; UV1.H13 129.91,131.02 v1(129.71,131.02) ; UV15.P3 v1(150.71,121.3) ; UV1.H19 130.54,134.92 v1(130.77,134.69) ; UV15.B12 v1(160.33,128.49) ; UV15.F12 v1(157.12,128.5) UV15.G13 ; v1(152.69,130.29) 152.71,130.28 UV15.M14 ; 149.51,137.93 UV13.T3 ; UV15.P14 151.11,130.15 151.04,130.22 v1(151.04,130.26) ; UV15.P1 v1(150.68,118.87) ; UV13.T14 v1(148.98,147.26) ; v1(152.31,128.51) 152.71,128.11 UV15.M12 ; UV15.T1 v1(149.94,118.88) ; UV13.L11 v1(153.11,143.93) ; UV15.L11 v1(153.93,126.88)
  BOTTOM w0.508: v1(132.69,145.89) 132.69,147.11 RV32.1 132.24,147.2 132.24,146.87 131.73,146.36 RV33.1 ; v1(157.62,132.53) 157.23,132.92 RV50.1 ; RV54.1 v1(153.62,148.36)
  vias: v1(127.75,131.51) v1(128.6,139) v1(128.6,138.2) v1(128.84,135.84) v1(128.92,129.76) v1(129.32,139.04) v1(129.43,127.8) v1(129.41,127.02) v1(149.32,135.82) v1(149.9,143.12) v1(149.91,139.94) v1(149.91,137.53) v1(150.72,135.87) v1(151.52,143.92) v1(151.51,137.53) v1(152.26,139.93) v1(153.04,121.31) v1(153.11,137.53) v1(153.11,135.93) v1(153.11,120.49) v1(153.11,118.87) v1(153.51,147.23) v1(153.91,146.35) v1(153.87,145.54) v1(153.87,139.09) v1(153.89,137.5) v1(155.93,116.11) v1(155.93,115.52) v1(156.29,144.72) v1(156.31,137.53) v1(156.57,116.11) v1(156.57,115.52) v1(157.11,147.13) v1(157.1,145.53) v1(157.1,139.13) v1(157.12,122.09) v1(157.15,116.11) v1(157.15,115.52) v1(157.53,135.79) v1(157.49,118.73) v1(157.74,116.11) v1(157.74,115.52) v1(157.9,137.53) v1(158.32,116.11) v1(158.32,115.52) v1(158.45,140.01) v1(158.61,142.99) v1(158.9,116.11) v1(158.9,115.52) v1(159.13,135.76) v1(159.42,120.51) v1(159.51,144.73) v1(159.51,143.93) v1(159.51,137.53) v1(159.56,143.13) v1(160.31,139.13) v1(160.31,137.53) v1(161.12,144.73) v1(161.11,135.93) v1(161.08,118.94) v1(161.19,120.52) v1(162.8,136.15) v1(163.05,140.33) v1(163.23,137.22) v1(163.33,147.25) v1(163.48,130.11) v1(163.46,129.02) v1(163.48,127.94) v1(163.5,126.86) v1(163.48,125.79) v1(163.48,124.71) v1(163.48,121.85) v1(163.48,120.77) v3(162.14,134.4)
+1.35VGPUP: length 15.8
  TOP w0.112: PCW05.1 v3(155.72,111.67)
  BOTTOM w0.254: 154.97,111.77 154.95,111.79 154.95,113.03 154.94,113.04 154.94,113.68 154.47,114.16 147.48,114.16 PCW14.1 146.17,112.84 143.92,112.84 PRW09.2
  vias: v1(154.02,110.56) v1(154.02,109.93) v1(154.73,110.56) v1(154.73,109.93) v1(155.37,109.93) v1(156.05,109.93) v1(156.76,109.93) v1(157.48,109.93)
+2.5V_MEM: length 61.8
  BOTTOM w1.016: 55.28,52 55.28,65.46 54.2,66.54 54.2,68.7 52.61,70.29 52.61,74.35 53.56,75.31 53.56,77.67 54.83,78.94 54.83,92.78 54.83,110.8 55.53,111.5
  vias: v1(55.72,51.24) v1(55.72,50.6) v1(58.96,111.06) v1(59.47,111.56) v1(67.73,43.81) v1(68.36,43.81) v1(77.96,43.75) v1(80.43,44) v3(79.8,43.72)
+2.5V_PG: length 128.5
  TOP w0.112: v1(40.17,102.1) 40.86,102.8 40.86,103.31 44.36,106.8 44.6,106.8 44.74,106.94 44.74,108.01 47.07,110.35 v2(55.56,110.35) 57.43,110.35 59.43,108.35 68,108.35 68.61,108.96 69.76,108.96
  TOP w0.254: PRM08.1 32.39,28.28 31.53,29.14 31.53,30.41 v1(32.1,30.98)
  IN2 w0.124: v1(40.17,102.1) 36.61,98.55 36.61,92.11 34.01,89.51 34.01,87.16 35.21,85.96 35.21,76.62 34.09,75.5 30.64,75.5 29.37,74.23 29.37,73.34 29.85,72.86 30.93,72.86 31.81,71.97 31.81,66.32 30.12,64.63 30.12,63.87 31.02,62.97 31.02,61.53 31.77,60.78 37.29,60.78 37.51,60.56 37.51,56.84 35.48,54.81 35.48,40.46 34.71,39.68 34.71,37.76 33.31,36.37 33.31,33.14 32.96,32.79 32.96,32.19 32.67,31.91 32.67,31.11 32.55,30.98 v1(32.1,30.98)
+2.5VP:
  vias: v3(62.51,113.11)
+3.3V_SPI: length 125.6
  TOP w0.254: 109.89,32.53 110.34,32.99 110.97,32.99 v1(111.48,32.49) 111.99,33 v3(112.67,33) 114.79,33 115.1,32.7 v1(115.1,32.52) ; 109.89,32.53 v1(109.89,32.52) ; 109.89,32.53 109.13,33.29 107.95,33.29 107.41,32.76 v1(107.41,32.38)
  IN1 w0.508: 116.37,59.49 116.3,59.56 114.67,59.56 113.89,58.78 113.89,58.1 112.17,56.38 109.55,56.38 108.8,55.63 107.11,55.63 104.43,52.94 104.43,52.26 v1(104.05,51.87)
  IN2 w0.254: v1(130.18,38.55) 130.16,38.55 129.8,38.91 126.01,38.91 125.24,38.14 122.05,38.14 121.59,38.6 v1(119.99,38.6)
  IN3 w0.254: v1(92.67,27.69) 98.88,33.9 105.89,33.9 v1(107.41,32.38)
  BOTTOM w0.203: UC1.BV23 v1(123.19,57.6)
  BOTTOM w0.254: UC11.8 132.24,26.47 131.99,26.73 131.05,26.73 CC74.1 131.02,27.36 131.81,27.36 132.06,27.62 132.06,29.87 132.5,30.3 135.43,30.3 136.81,31.68 136.81,33.71 135.68,34.85 132.33,34.85 RC207.1 131.09,36.8 RC31.1 131.56,37.51 131.1,37.97 130.76,37.97 v1(130.18,38.55) ; RC35.1 109.76,32.65 v1(109.89,32.52) ; v1(111.48,32.49) 111.29,32.68 RC37.1 ; v1(92.67,27.69) 92.65,27.7 92.65,33.09 90.59,35.15 90.59,36.42 91.03,36.86 92.39,36.86 93.6,38.07 93.6,38.72 95.04,40.16 96.44,40.16 99.6,43.31 99.6,44.64 99.85,44.88 99.85,46.72 104.05,50.92 v1(104.05,51.87) ; RC30.2 117.57,38.35 117.16,37.94 115.73,34.5 115.73,33.74 115.12,33.13 RC36.1 v1(115.1,32.52) ; RC30.2 119.35,38.6 v1(119.99,38.6) ; RC30.2 119.11,38.34 119.11,37.65 CC4.1 UC3.8 ; v1(107.41,32.38) 107.41,33.07 RC149.1
+3.3V_WLAN:
  vias: v1(69.63,136.58) v1(69.63,118.4) v1(69.88,137.22) v1(70.27,136.71) v1(70.32,118.51) v1(70.93,118.7) v1(71.54,139.41) v1(71.51,118.69) v3(70.54,137.24) v3(70.75,139.37) v3(71.37,118)
+3V_DVDD: length 7.5
  TOP w0.127: v3(37.68,16.66) 38.38,15.96 RA6.2
  TOP w0.305: v1(34.96,18.6) 34.96,18.6 34.65,18.3 RA15.2
  IN1 w0.381: 34.39,13.52 34.39,18.03 v1(34.96,18.6)
  vias: v1(35.47,9.77) v1(36.1,9.71) v1(36.43,14.44) v1(37,14.6)
+3V_HDA: length 23.4
  TOP w0.112: v1(107.94,61.53) v3(108.5,61.53)
  TOP w0.381: RC131.2 124.44,60.64 124.04,60.23 CC60.1 124.04,59.56 v1(124.03,59.55)
  IN1 w0.203: v1(124.03,59.55) 124,59.55 122.79,60.75 122.79,61.79 123.16,62.16 123.16,62.86 122.72,63.3 120.62,63.3 120.31,62.99 110.89,62.99 109.42,61.53 v1(107.94,61.53)
  BOTTOM w0.254: UC1.BT20 v1(124.03,59.55)
  BOTTOM w0.508: v1(107.94,61.53) 108.49,61.53 RC51.1
+3VALW: length 398.5
  TOP w0.254: PRW03.1 147.39,111.5 v1(147.91,112.02) ; PRH03.1 165.9,42.03 166.4,41.52 v1(166.4,41.33) 165.9,40.83 PR41.2
  TOP w0.356: v1(54.77,75.83) 54.71,75.76 54.31,75.76 RE81.1 ; RE86.1 54.88,74.35 55.03,74.21 v1(55.15,74.21) ; RE70.1 31.29,76.92 30.83,77.38 v1(30.83,77.89) ; v1(39.66,87.67) 39.53,87.54 RE58.1 38.81,86.88 RE89.1
  TOP w0.381: 98.08,44.76 97.71,44.4 UC8.5 ; 98.08,44.76 98.46,44.38 98.46,43.94 ; 98.08,44.76 98.08,45.47 CC70.1 98.03,46.4 97.65,46.78 95.02,46.78 94.41,47.39 94.41,50.11 95.27,50.97 UC9.5 ; RE67.1 RE66.1 33.97,83.17 v1(34.25,83.45) ; CC13.1 98.88,58.49 UC5.5 ; RE70.1 RE71.1 RE72.1 RE73.1
  TOP w0.406: 96.68,39.3 97.3,39.92 UC6.5 97.3,40.75 98.03,41.47 CC67.1
  TOP w0.508: v1(98.81,57.15) 98.89,57.22 CC13.1 ; 55.15,68.49 55.76,67.88 55.76,66.92 55.18,66.35 55.18,64.76 51.68,61.26 46.98,61.26 46.96,61.27 ; PR5.2 53.06,128.27 53.56,127.76 55.91,127.76 v1(56.55,128.39) ; RX18.2 91.64,32.37 CX2.1 CX1.1 91.64,30.34 92.15,29.83 98.9,29.83 v1(98.97,29.9) 98.97,32.65 97.13,34.49 97.13,36.86 96.68,37.31 96.68,39.3 ; RC175.1 120.43,42.92 120.21,42.7 v1(120.21,41.98) 120.21,41.94 120.68,41.46 123.4,41.46 124.82,40.04 124.82,35.16 123.82,34.16 v1(123.67,34.16) ; 45.4,87.86 44.37,87.86 44.18,87.67 v1(42.2,87.67) 41.44,86.91 RE87.1 ; 47.77,87.86 48.96,89.05 52.78,89.05 53.63,88.2 RE5.1 52.58,87.12 RE28.1 ; UC9.5 96.24,50.97 96.8,50.41 v1(97.19,50.41) ; RE19.2 42.96,62.62 42.34,62 ; PRM06.1 31.18,26.66 30.26,25.74 30.26,22.28 v1(30.51,22.03) RA9.2 ; PR2505.1 68.52,107.87 59.23,107.87 57.31,109.79 v3(51.76,109.79) 50.69,109.79 48.27,107.37 v1(45.25,107.37) ; v1(30.51,85.02) 29.75,85.78 28.99,85.78 28.6,86.18 RE21.2 28.58,86.7 27.59,87.69 27.59,88.37 25.25,90.71 v1(23.47,90.71) 23.47,89.56 22.63,88.72 RL10.1 ; v1(173.88,33.76) 173.47,33.76 172.3,34.93 PR33.1 171.1,35.73 171.17,35.8 v1(171.17,36.96) ; RT23.1 v1(18.96,115.31) ; 98.46,43.94 98.46,42.72 98.03,42.29 CC67.1
  IN1 w0.254: v1(168.44,46.41) 168.82,46.03 168.82,44 166.4,41.59 v1(166.4,41.33) 166.4,37.51 168.04,35.87 170.08,35.87 v1(171.17,36.96)
  IN1 w0.508: v1(30.83,77.89) 32.7,77.89 34.25,79.43 v1(34.25,83.45) 33.18,84.51 31.02,84.51 v1(30.51,85.02) ; v1(56.55,128.39) 53.84,125.68 53.84,122.82 52.11,121.09 51.4,121.09 47.98,117.66 v1(47.98,115.76) 45.12,115.76 43.42,114.05 43.42,109.2 v1(45.25,107.37) ; v1(200.95,59.37) 204.31,59.37 v1(207.55,56.13) ; v1(39.66,87.67) v1(42.2,87.67)
  IN2 w0.508: 54.01,74.1 54.01,74.1 55.04,74.1 v1(55.15,74.21) ; 54.01,74.1 54.01,70.8 v1(54.68,70.12) ; 54.01,74.1 54.01,75.32 54.52,75.83 v1(54.77,75.83) ; v1(120.21,41.98) 120.21,42.7 120.3,42.79 120.3,43.3 120.81,43.8 127.74,43.8 128.33,43.21 v1(128.33,42.71) ; v1(147.91,112.02) 147.91,112.83 147.02,113.72 138.88,113.72 136.6,116.01 131.16,116.01 130.88,116.29 125.04,116.29 124.96,116.2 123.28,116.2 123.2,116.29 106.39,116.29 102.63,112.52 87.83,112.52 84.84,115.5 v1(78.39,115.5) 77.76,115.5 76.8,114.54 49.19,114.54 v1(47.98,115.76)
  IN3 w0.508: v1(39.66,87.67) 39.66,87.45 38.04,85.83 35.77,85.83 34.25,84.31 v1(34.25,83.45)
  BOTTOM w0.203: JDB1.11 144.94,35.8 144.85,35.7
  BOTTOM w0.254: PRH05.1 168.18,46.67 v1(168.44,46.41) ; PR1803.1 v1(200.95,59.37)
  BOTTOM w0.432: v1(128.33,42.71) 128.35,42.73 128.51,42.73 128.86,43.09 RC174.1
  BOTTOM w0.508: v1(106.76,29.9) 106.76,29.64 C23.1 107.58,29.09 Q5.3 ; RT6.2 RT11.2 RT10.2 RT8.2 RT7.2 34.78,128.33 v1(34.53,128.58) 34.53,129.14 34.2,129.47 34.2,130.49 33.31,131.38 R89.1 ; JPWR1.4 224.24,63.23 224.75,62.72 225.62,62.72 v1(225.92,63.03) ; 144.85,35.7 143.42,34.27 143.42,32.19 145.07,30.54 v1(148.24,30.54) ; v1(98.81,57.15) 97.19,55.52 v1(97.19,50.41)
  vias: v1(13.64,86.5) v1(13.62,85.78) v1(17.65,86.66) v1(17.81,87.43) v1(32.01,55.88) v1(31.99,54.76) v1(32.3,55.33) v1(32.3,54.19) v1(32.65,55.88) v1(32.61,54.76) v1(32.93,54.19) v1(32.93,53.55) v1(32.97,55.33) v1(33.23,55.88) v1(33.19,54.77) v1(33.51,54.2) v1(33.51,53.56) v1(33.59,55.34) v1(68.07,31.3) v1(68.68,31.3) v1(207.93,55.56) v1(208.19,56.13) v3(34.45,56.54) v3(77.75,115.18)
+3VALW_1.8V: length 1.3
  TOP w0.112: v2(206.68,52.24) 206.41,52.51 v1(206.41,53.46)
  vias: v1(205.77,53.46) v1(207.04,53.46)
+3VALW_2.5V: length 1.7
  TOP w0.112: 75.6,113.41 75.83,113.41 v3(76.84,112.39)
+3VALW_DSW: length 36.8
  TOP w0.127: v1(123.24,58.88) 123.29,58.88 v2(123.63,58.54)
  TOP w0.381: v1(123.24,58.88) 123.15,58.8 122.75,58.8 CC63.1 122.61,58.11 RC132.2
  TOP w0.508: RC103.1 101.6,60.57 101.09,60.07 101.09,59.35 101.39,59.05 v1(101.39,59.04) ; v1(103.79,54.16) 104.36,54.73 RC92.1
  IN1 w0.254: 121,61.06 121.21,60.85 121.5,60.85 122.01,60.34 122.01,59.91 121.65,59.55 v1(121.51,59.55) 121.36,59.55 121,59.91 121,61.06 ; 121,61.06 120.96,61.1
  IN1 w0.508: 120.96,61.1 120.71,61.35 116.44,61.35 115.56,60.47 113.66,60.47 110.4,57.21 v1(110.21,57.21)
  BOTTOM w0.203: UC1.BR24 121.51,59.55 v1(121.51,59.55) ; v1(123.24,58.88) 123.21,58.88 UC1.BT23
  BOTTOM w0.508: v1(103.79,54.16) 106.19,56.56 106.19,58.27 ; v1(101.39,59.04) 101.48,59.04 102.25,58.27 106.19,58.27 ; 106.19,58.27 108.21,58.27 RC97.1
+3VALW_EC: length 279.8
  TOP w0.203: 48.99,73.41 49.09,73.5 50.42,73.5 50.51,73.41 UE1.43 53.39,73.41 CE6.1 ; CE2.1 38.71,66.02 38.71,66.57 v1(38.7,66.57) 38.73,66.57 38.95,66.79 UE1.5 ; v1(37.07,74.92) 36.76,74.61 UE1.115 34.68,74.61 34.54,74.75 RE94.2 CE3.2 ; CE5.1 42.95,86.08 v1(42.95,85.28) UE1.82 ; UE1.22 v1(45.75,66.42) 45.75,65.54 CE4.2 ; CE7.1 33.87,79.81 34.28,79.41 UE1.103 ; CE17.1 44.55,65.6 UE1.19
  TOP w0.508: v1(38.2,93.4) 38.07,93.53 RE52.1 RE51.1 ; RE48.1 45.18,94.03 45.69,94.53 45.69,94.56 v1(45.72,94.59) 46.6,94.59 47.23,93.96 RE60.2 ; RE8.2 RE9.2 RE10.2 RE11.2 42.2,62.93 v1(42.13,62.86) ; v1(33.05,80.58) 33.23,80.4 CE7.1 ; v1(132.88,45.4) 132.75,45.52 R52.1 ; v1(49.12,66.36) 49.17,66.32 51.45,66.32 52.18,65.59 RE36.1 53.46,65.46 53.96,65.96 RE12.2 ; 48.99,73.41 42.37,73.41 v1(42.31,73.46) ; v1(44.04,93.28) 44.29,93.53 RE90.1 RE91.1 RE92.1 RE93.1 RE49.1 RE50.1 40.48,93.28 v1(40.67,93.09) ; v1(30.33,86.89) 30.68,87.24 RE3.1 30.94,87.25 v3(30.94,89.34) 30.94,90.52 31.53,91.11 CE21.1 33.23,92.01 RE1.1 ; CE17.1 CE4.2 RE35.1
  IN1 w0.508: v1(44.04,93.28) 44.41,93.28 v1(45.72,94.59) ; v1(45.75,66.42) 45.11,67.06 39.22,67.06 38.73,66.57 v1(38.7,66.57) ; v1(40.67,93.09) 40.15,93.61 38.4,93.61 v1(38.2,93.4) ; v1(38.26,81.08) 38.71,81.08 40.93,83.31 40.93,84.77 41.58,85.42 42.81,85.42 v1(42.95,85.28) ; v1(49.12,66.36) 49.32,66.17 49.32,61.99 48.81,61.48 43.58,61.48 42.2,62.86 v1(42.13,62.86)
  IN2 w0.254: v1(45.75,66.42) 47.22,64.95 47.22,62.45 49.04,60.63 49.04,56.92 50.58,55.38 50.58,47.73 51.46,46.85 51.46,42.1 52.67,40.89 54.35,40.89 55.73,39.52 58,39.52 61.28,36.24 68.24,36.24 68.56,35.93 78.5,35.93 81.52,38.94 84.43,38.94 84.91,38.46 94.35,38.46 94.49,38.32 97.33,38.32 97.78,38.77 99.4,38.77 100.6,39.97 107.69,39.97 111.01,43.29 114.76,43.29 116.96,41.1 118.03,41.1 118.97,42.05 118.97,43.36 120.02,44.41 130.69,44.41 131.8,45.52 132.75,45.52 v1(132.88,45.4)
  IN2 w0.508: v1(38.7,66.57) 38.7,66.55 39.21,66.04 39.21,65.01 39.72,64.5 41.24,64.5 42.13,63.6 v1(42.13,62.86) ; v1(42.31,73.46) 41.63,74.15 41.63,79.72 42.18,80.27 42.18,84.03 42.95,84.81 v1(42.95,85.28) ; v1(38.26,81.08) 38.02,80.85 38.02,80.4 36.93,79.31 36.93,75.06 v1(37.07,74.92)
  IN3 w0.508: v1(30.33,86.89) 31.12,86.1 31.12,84.69 30.68,84.25 30.68,82.95 31.12,82.51 31.12,81.3 31.85,80.58 v1(33.05,80.58) 33.11,80.64 37.7,80.64 38.15,81.08 v1(38.26,81.08) ; v1(42.95,85.28) 42.95,90.22 44.99,92.26 44.99,93.86 v1(45.72,94.59)
  BOTTOM w0.305: JESPI1.2 45.44,94.87 v1(45.72,94.59) 45.5,94.37 JESPI1.1
  BOTTOM w0.508: v1(42.31,73.46) 43.07,72.7 43.07,69.1 v1(45.75,66.42) ; v1(50.22,83.5) 44.73,83.5 v1(42.95,85.28)
+3VALW_PCH: length 257.4
  TOP w0.254: v1(128.99,45.92) 129.07,45.92 129.07,45.92 129.21,45.92 129.57,46.29 129.57,47.43 129.62,47.48 129.62,47.49 129.89,47.76 130.46,47.76 130.72,48.01 RC70.1 RC188.2 RC191.2 RC189.2 RC190.2 ; v1(119.16,47.34) 119.63,47.81 CC66.1 CC65.1 ; CC65.1 119.63,48.97 RC112.1 ; CC65.1 119.29,48.45 119.05,48.69 RC183.1 RC182.1 117.78,49.04 RC208.1 ; RC69.1 127.16,45.84 126.65,45.33 ; v1(108.81,48.13) 113.75,53.07 RC46.1
  TOP w0.432: RC132.1 122.64,56.95 v1(123.19,56.95)
  TOP w0.508: v1(123.38,61.54) 123.53,61.39 RC131.1 ; RC62.1 119.67,43.53 119.65,43.51 v1(119.65,43.21) ; v1(90.65,44.6) 86.8,44.6 84.54,42.34 RX17.2 83.68,41.91 79.83,38.06 RX16.2
  TOP w1.016: 52.49,98.61 49.95,98.61 46.26,102.29 43.6,102.29 41.47,100.17 39.91,100.17 38.9,101.19 38.9,103.44 46.9,111.44 46.9,115.25 45.75,116.39 45.75,119.69 ; 66.96,139.38 64.8,139.38 59.66,134.23
  IN2 w0.508: 121.89,42.54 v1(121.89,43.05) ; 121.89,42.54 120.68,41.33 119.92,41.33 v1(119.73,41.14) ; 121.89,42.54 122.21,42.22 122.64,42.22 123.98,40.89 127.04,40.89 127.14,40.79 129.4,40.79 129.85,41.25
  IN2 w1.016: 59.2,132.25 53.88,126.93 52.36,126.93 46.96,121.53 ; 54.14,98.65 54.14,80.83 56.04,78.93 56.04,57.21
  IN3 w0.254: v1(130.67,39.68) 130.67,39.79 129.98,40.48 129.98,42.62 129.54,43.06 v1(129.43,43.06) 129.43,45.37 129.39,45.42 129.39,45.52 v1(128.99,45.92)
  IN3 w1.016: 68.93,39.05 64.23,39.05 63.09,40.19 61.06,40.19 60.61,40.64 59.41,40.64 58.33,41.71 56.42,41.71 54.71,43.43 54.71,44.76 53.06,46.41 53.06,53.14 56.62,56.71 v1(56.92,56.71)
  BOTTOM w0.2: v1(126.55,55) UC1.CB16
  BOTTOM w0.203: v1(123.18,55.03) UC1.CC23 v1(123.19,54.35) ; v1(123.18,55.03) UC1.CC22 v1(123.19,54.35) ; v1(123.18,55.03) UC1.CB23 123.17,55.73 v1(123.17,56.35) 123.19,56.36 v1(123.19,56.95) UC1.BW23 ; v1(123.18,55.03) UC1.CB22 ; UC1.CP29 118.93,48.3 119.03,48.19 119.03,47.47 v1(119.16,47.34) ; v1(123.19,54.35) UC1.CD22 v1(123.19,53.7) UC1.CD23 v1(123.19,54.35) ; UC1.CB16 v1(127.39,55)
  BOTTOM w0.254: RC198.1 130.55,39.56 v1(130.67,39.68) ; UC1.BP23 123.09,60.84 123.09,61.25 v1(123.38,61.54)
  BOTTOM w0.381: RC197.1 RC196.1 127.34,43.11 v1(127.75,42.71)
  BOTTOM w0.457: RC199.1 129.22,42.43 v1(129.49,42.43) ; RC113.1 129.62,43.25 v1(129.43,43.06)
  BOTTOM w0.508: v1(121.89,43.05) 121.89,43.06 121.89,43.86 RC117.1 RC111.1 ; RC57.1 108.67,48.27 v1(108.81,48.13) ; RC59.1 RC65.1 119.19,43.67 v1(119.65,43.21) ; RC100.1 RC110.1 RC113.1 ; v1(119.73,41.14) 119.73,40.38 RC30.1 ; v1(107.27,51.31) 107.27,51.33 107.27,54.19 108.02,54.94 108.94,54.94 109.46,55.45 RC118.1 RC115.1
  BOTTOM w1.016: 94.01,45.13 93.48,44.6 v1(90.65,44.6) 89.15,46.1 84.11,46.1 82.67,44.66 82.67,41.11 80.23,38.67 71.66,38.67
  vias: v1(45.5,120.71) v1(46.14,120.71) v1(53.25,99.5) v1(53.25,98.86) v1(56.98,55.74) v1(59.22,133.35) v1(59.85,133.35) v1(69.95,38.79) v1(70.58,38.79) v1(95.02,46.04) v1(95.03,45.43) v3(52.33,99.56)
+3VALW_PCH_OUT: length 0.8
  TOP w0.112: 68.93,34.98 v3(68.11,34.98)
+3VALWP: length 51.7
  TOP w0.254: PR304.1 20.44,45.09 v1(20.44,45.47) 21.08,46.11 21.08,48.46 v1(20.86,48.67) 20.86,50.22 22.39,51.75 23.28,51.75 23.46,51.94 23.78,51.94 PC312.1
  IN1 w0.254: v1(30.01,91.94) 30.01,90.8 29.63,90.42 29.63,84.73 31.66,82.7 31.66,80.61 30.98,79.94 30.98,79.33 30.2,78.54 30.2,75.81 26.7,72.32 26.7,57.53 v1(26.64,57.46)
  BOTTOM w0.254: PR307.1 20.66,47.81 PR306.2 20.61,48.42 v1(20.86,48.67) ; v1(20.44,45.47) 20.44,45.23 20.34,45.13 PU301.14 ; PR504.1 29.64,92.31 v1(30.01,91.94)
  vias: v1(25.42,52.29) v1(25.42,51.71) v1(26.01,52.29) v1(26.01,51.71) v1(26.59,52.29) v1(26.59,51.71) v3(25.92,50.97)
+3VGS: length 125.2
  TOP w0.203: v1(67.22,130.23) PRV14.1
  TOP w0.356: QV1.5 QV1.2 124.31,120.53 123.81,120.03 123.81,119.67
  TOP w0.381: v1(58.33,124.01) 59.17,123.17 CV32.2 60.54,123.17 60.85,123.49 UV3.5 ; QV1.5 124.31,122.89 123.95,123.25 RV5.1
  TOP w0.508: v1(123.27,117.75) 122.66,118.36 RV6.1 123.81,119.67 v3(124.24,119.25) 125.52,119.25 RV80.2 126.32,119.74 v1(126.97,120.39) 126.97,120.76 RV17.1
  IN1 w0.254: v1(108.62,134.3) 108.62,134.15 107.73,133.26 106.97,133.26 98.61,141.62 94.96,141.62 91.54,138.2 88.8,138.2 85.24,134.63 82.21,134.63 81.83,135.01 79.37,135.01 76.87,132.52 68.23,132.52 67.73,132.01 67.73,130.74 v1(67.22,130.23)
  IN1 w0.508: v1(126.97,120.39) 126.3,119.72 126.3,116.52 127.1,115.72 v1(127.1,113.81)
  IN2 w0.254: v1(58.33,124.01) 57.95,124.39 57.95,125.53 60.49,128.07 60.49,130.36 60.99,130.87 66.91,130.87 67.22,130.56 v1(67.22,130.23)
  IN2 w0.508: v1(123.27,117.75) 122.42,116.9 112.05,116.9 v1(111.22,117.72)
  BOTTOM w0.381: RV26.2 108.81,123.57 109.4,122.98 UV2.5
  BOTTOM w0.406: UV2.5 109.4,121.59 111.22,119.76 v1(111.22,117.72)
  BOTTOM w0.508: RV22.1 123.27,118.49 v1(123.27,117.75) ; RV26.2 108.62,123.93 108.11,124.44 108.11,125.17 106.49,126.79 106.49,128 107.2,128.71 107.2,130.12 108,130.92 108,132.73 108.71,133.44 108.71,134.2 v1(108.62,134.3) 109.19,134.87 RV10.1 109.19,135.63 109.3,135.75 RV162.1
+3VGS_GPU_ON: length 3.6
  BOTTOM w0.112: RZ5.2 137.68,114.23 v2(137.68,114.04)
  BOTTOM w0.254: UZ5.3 136.24,115.91 136.29,115.95 CZ25.2 136.79,115.11 RZ5.2
+3VGS_OUT: length 2.1
  BOTTOM w0.112: 131.48,114.31 v2(131.48,112.25)
+3VLP: length 109.5
  TOP w0.254: RE30.2 31.08,73.57 v1(30.56,73.57)
  TOP w0.508: D1.2 64.35,29.35 63.56,30.14 v1(63.56,30.6) ; v1(47.91,47.18) v3(44.37,47.18) 38.45,47.18 v1(33.56,42.29) ; PC308.1 20.98,44.39 v1(21.47,44.89)
  IN1 w0.254: v1(23.69,61.3) 23.11,60.71 23.11,59.02 21.61,57.52 21.61,53.38 20.82,52.59 20.82,50.76 20.59,50.53 20.3,50.24 20.3,46.83 21.47,45.66 v1(21.47,44.89)
  IN2 w0.254: v1(30.56,73.57) 31.29,73.57 32.24,72.63 33.44,72.63 33.69,72.37 33.69,70.42 33.06,69.78 33.06,66.95 34.93,65.07 34.93,64.25 35.45,63.74 v1(35.72,63.74)
  IN2 w0.508: v1(47.91,47.18) 47.53,46.79 47.53,39.87 51.32,36.08 56.57,36.08 57.16,35.49 57.16,34.84 60.86,31.15 61.27,31.15 62.09,30.33 63.28,30.33 v1(63.56,30.6)
  IN3 w0.254: v1(23.69,61.3) 24.53,62.14 25.76,62.14 28.45,64.83 31.87,64.83 32.96,63.74 v1(35.72,63.74)
  IN3 w0.508: v1(21.47,44.89) 21.47,43.14 22.98,41.63 31.03,41.63 31.69,42.29 v1(33.56,42.29)
+3VS: length 524.4
  TOP w0.254: v1(211.23,54.14) 210.22,53.13 208.32,53.13 207.96,53.49 207.96,54.63 RC204.1 208.97,55.65 R90.1
  TOP w0.356: 42.2,55.11 43.47,53.84 43.47,49.53 44.55,48.45 50.77,48.45 54.45,44.76 RD15.1 RD17.1 ; RD4.1 RD2.1 v1(69.63,41.96) ; RE16.2 55.18,72.69 56.25,71.62 ; RD6.1 66.8,68.11 65.19,69.72 60.49,69.72 58.33,71.88 57.47,71.88 v1(56.99,72.36) ; v1(93.7,52.83) 94.52,52.83 95.33,53.64 UC4.5 ; RE17.2 56.99,74.21 v1(56.99,72.36) ; 56.25,71.62 56.4,71.47 56.4,67.89 RD19.1 ; 56.25,71.62 v1(56.99,72.36)
  TOP w0.381: R88.1 215.25,48.19 214.87,47.81 v1(214.8,47.81)
  TOP w0.406: UE2.5 40.96,90.5 CE22.1 ; Q11.5 175.99,69.2 R50.1 ; Q11.2 175.99,65.41 R49.1
  TOP w0.432: Q10.5 120.22,28.89 120.54,28.57 v1(120.75,28.57)
  TOP w0.457: Q10.2 v1(117.42,28.89)
  TOP w0.508: v1(25.29,87.55) 24.96,87.22 RL8.1 ; RC203.1 145.88,50.41 v1(145.95,50.34) 146.97,49.32 146.97,44.45 148.31,43.11 v1(148.81,43.11) ; v1(81.37,36.98) 81.37,38.43 84.01,41.07 RX20.2 ; v1(58.71,35.63) 58.71,36.12 58.01,36.83 55.5,36.83 54.85,36.18 53.58,36.18 Q9.2 52.46,35.06 R47.1 ; RC8.1 RC7.1 145.58,53.91 v1(145.97,53.52) ; v1(66.33,119.06) 65.69,119.69 63.53,119.69 61.12,122.11 57.82,122.11 57.16,122.77 v3(57.16,126.64) 57.16,129.64 63.22,135.69 70.57,135.69 71.13,136.25 RC81.1 ; v1(93.63,47.56) 93.63,47.3 94.27,46.67 RC146.1 ; R86.1 207.95,42.16 208.68,42.16 209.05,41.79 209.05,41.61 209.9,40.76 v1(209.9,39.68) R87.1 207.76,39.43 207.25,38.92 207.17,38.92 205.85,37.6 R92.1 ; R49.1 176.2,64.84 v1(175.8,64.45) ; R36.1 121.01,28.84 v1(120.75,28.57) ; RC106.1 103.92,49.33 102.8,48.22 v1(102.8,48.13) ; v1(116.61,30.61) 116.62,30.61 116.62,30.54 116.37,30.28 116.37,29.85 R37.1 ; v1(40.42,91.37) 40.98,90.81 CE22.1 ; 218.58,31.82 219.81,31.82 221.58,33.59 v1(222.67,33.59) 222.67,36.89 221.65,37.9 v1(221.4,37.9) ; PRV17.1 79.79,124.26 80.49,123.57 v1(80.49,123.44) ; RX12.2 92.34,37.14 CX4.1 CX3.1 92.78,36.22 93.35,35.64 v1(93.35,35.24) 93.38,35.21 RX19.2 ; v1(211.47,43.47) 211.55,43.55 R95.1 ; RC19.1 107.86,110.68 105.95,112.58 v1(105.95,112.83) ; v1(31.73,83.75) 31.14,83.16 31.14,81.81 RC85.1 ; v1(137.63,116.95) 135.53,116.95 134.29,115.71 128.2,115.71 127.2,114.7 v1(126.2,114.7) 106.04,114.7 v1(105.95,114.61) 98.46,114.61 96.3,116.77 v1(95.28,116.77) 94.65,116.14 90.08,116.14 v1(89.51,116.71) 89.51,117.33 RC68.1 ; v1(175.17,69.27) R50.1
  IN1 w0.254: v1(38.39,17.65) 38.39,19.21 38.06,19.54 37.54,20.06 37.54,24.3 36.38,25.46 33.85,25.46 30.77,28.55 30.77,29.84 30.01,30.6 v1(30.01,31.17)
  IN1 w0.508: v1(181.37,64.19) 181.37,60.15 182.45,59.07 v1(182.72,59.07) ; v1(213.86,39.59) 214.38,39.06 214.38,35.29 215.74,33.93 v1(215.74,32.27) ; v1(191.3,60.97) 191.3,61.53 191.8,62.03 194.35,62.03 195.11,62.8 201.75,62.8 206.45,58.1 211.3,58.1 211.74,58.54 216.63,58.54 217.46,57.72 220.06,57.72 v1(221.14,58.8) ; v1(28.74,88.96) 28.67,89.02 28.67,91.44 31.4,94.17 31.4,103.44 27.92,106.92 24.08,106.92 23.5,107.5 14.13,107.5 12.47,109.17 v1(12.47,110.41) 12.47,116.69 16.59,120.82 16.59,126.28 18.77,128.46 26.07,128.46 26.58,127.95 26.58,127.06 27.16,126.47 v1(28.94,126.47)
  IN2 w0.381: v1(117.42,28.89) 119.01,28.89 119.1,28.8 120.52,28.8 v1(120.75,28.57)
  IN2 w0.508: v1(95.28,116.77) 95.28,119.23 92.99,121.52 90.31,121.52 89.88,121.09 84.41,121.09 82.06,123.44 v1(80.49,123.44) ; v1(28.74,88.96) 30.32,88.96 31.17,88.11 31.17,84.31 v1(31.73,83.75)
  IN3 w0.508: v1(145.97,53.52) 145.95,53.5 v1(145.95,50.34) ; v1(40.42,91.37) 40.17,91.63 39.15,91.63 35.81,88.28 29.41,88.28 v1(28.74,88.96) 28.67,89.02 28.67,90.38 28.16,90.89 27.23,90.89 26.03,89.68 26.03,88.43 25.29,87.69 v1(25.29,87.55) ; v1(191.3,60.97) 191.3,61.02 190.6,61.72 187.61,61.72 187.09,62.24 183.32,62.24 v1(181.37,64.19)
  BOTTOM w0.305: v1(77.25,43.01) 77.25,44.25 77.48,44.49 JDIMM1.255 ; JDIMM2.255 65.36,44.49 v1(64.52,43.65)
  BOTTOM w0.356: C28.1 182.28,62.16 181.75,62.16 181.08,62.84 U3.1
  BOTTOM w0.381: 179.97,63.41 180.51,63.41 U3.1
  BOTTOM w0.406: QI3.2 28.47,88.69 v1(28.74,88.96) ; v1(25.29,87.55) 25.29,88.12 25.86,88.69 QI3.5
  BOTTOM w0.432: RC29.1 125.16,40.43 QC1.2 126.24,40.55 127.9,40.55 QC1.5 129.08,40.43 RC28.1
  BOTTOM w0.508: v1(12.47,110.41) QI2.2 12.47,111.8 12.66,112 RI13.1 ; RO1.2 v1(191.3,60.97) ; v1(28.94,126.47) R30.1 R31.1 ; R5.1 R6.1 223.12,33.13 v1(222.67,33.59) ; PRZ16.1 181.05,58.52 181.6,59.07 v1(182.72,59.07) ; v1(117.42,28.89) 117.42,29.79 v1(116.61,30.61) 116.61,32.29 116.93,32.62 116.93,34.37 116.73,35.09 116.73,35.64 116.93,36.08 v1(117.5,37.15) ; 179.97,63.41 178.43,61.87 R55.1 ; RC27.1 v1(121.07,43.02) RC114.1 ; RC28.1 RC109.1 RC127.2 130.89,41.51 v1(130.57,41.84) ; v1(93.7,52.83) 94.05,52.47 94.05,47.98 v1(93.63,47.56) ; v1(221.4,37.9) 220.96,37.47 R91.1 ; v1(175.17,69.27) 175.17,70.16 175.68,70.67 178.53,70.67 180.63,68.58 180.63,65.59 181.37,64.85 v1(181.37,64.19) 181.37,63.62 181.87,63.11 182.72,63.11 182.81,63.03 182.81,62.31 182.48,61.98 C28.1 ; v1(175.17,69.27) 174.79,68.89 174.79,65.46 v1(175.8,64.45) ; v1(175.17,69.27) 175.42,69.27 176.63,68.06 R54.1 ; RC9.1 141.72,51.37 142.25,50.83 145.46,50.83 v1(145.95,50.34) ; v1(191.17,37.49) 191.17,38.03 190.66,38.54 RC206.1 ; v1(124.21,39.56) 124.21,39.57 124.43,39.79 124.43,39.85 124.97,40.39 RC29.1 ; v1(126.2,114.7) 126.11,114.61 125.38,114.61 125.07,114.93 125.07,115.76 125.45,116.14 RC78.1 ; v1(102.8,48.13) 102.8,48.22 103.79,49.21 107.15,49.21 RC6.1 108.67,51.04 109.05,51.42 RC5.1 ; v1(170.02,32) 170.02,29.29 170.72,28.59 v1(170.72,28.29) ; v1(137.63,116.95) 138.29,116.95 138.97,116.26 138.97,115.25 140.95,113.27 PRW05.1 ; v1(105.95,114.61) v1(105.95,112.83)
  vias: v1(29.37,32.32) v1(29.37,31.68) v1(30.01,31.81) v1(40.7,56.65) v1(40.72,56.02) v1(40.72,55.38) v1(41.36,56.62) v1(41.36,55.99) v1(41.36,55.35) v1(66.33,118.42) v1(66.96,119.06) v1(66.96,118.42) v1(83.18,36.79) v1(200.92,38.92) v1(201.51,38.92) v1(202.09,38.92) v1(220.82,59.37) v1(221.46,59.37)
+3VS_CAM: length 5.5
  TOP w0.508: C36.1 R83.1 ; R83.1 213.64,45.56 v2(213.7,45.63) 213.77,45.7 213.77,46.42 v1(213.58,46.6) ; R83.1 212.73,44.6 R95.2
  BOTTOM w0.305: JEDP1.29 213.43,46.45 v1(213.58,46.6)
+3VS_SSD: length 6.6
  BOTTOM w0.508: 23.78,30.22 23.78,33 24.74,33.96 RS1.1
  vias: v1(23.83,26.67) v1(23.83,26.08) v1(24.46,26.67) v1(24.46,26.08) v3(24.35,28.85) v3(25.08,27.15) v3(26.5,25.92)
+5V_AVDD:
  vias: v2(29.03,16.63)
+5V_HDD: length 31.2
  TOP w0.127: 185,35.42 v3(185.76,35.42) ; 183.63,36.71 v3(183.63,37.49) ; 184.63,33.9 185.31,33.22 v3(185.31,32.69)
  TOP w0.254: RS32.2 183.51,33.87 RB9.2 ; RS31.1 164.55,31.76 v1(163.93,31.14)
  IN1 w0.254: v1(163.93,31.14) 164.29,31.14 164.9,30.53 172.18,30.53 173.41,29.29 175.33,29.29 177.11,31.07 177.11,31.38 182.41,36.69 v1(184.31,36.69)
  vias: v1(185.07,36.69)
+5V_HDMI: length 2.5
  TOP w0.127: v3(15.31,103.48) 16.29,102.5 FI1.1
  vias: v1(14.7,100.64) v1(14.7,100.01)
+5V_KB_BL: length 0.7
  TOP w0.127: v1(98.05,36.57) v3(98.05,35.87)
+5V_PVDD: length 1.7
  TOP w0.127: RA1.2 v3(36.27,5.48)
+5VALW: length 279.4
  TOP w0.178: 78.71,130.42 78.71,130.36 78.67,130.32 78.67,130.15 78.09,129.57 77.67,129.57 77.34,129.9 PUV01.26
  TOP w0.203: PUV01.31 75.98,133.15 ; UZ3.4 v1(37.09,58.03)
  TOP w0.254: PRV13.1 79.6,133.35 80.3,134.04 80.3,135.69 79.66,136.33 76.11,136.33 75.52,135.75 75.52,133.6 75.98,133.15
  TOP w0.305: UZ2.3 152.62,40.52 153.07,40.06 v1(153.26,40.06) 153.75,40.06 CZ10.1
  TOP w0.381: v1(156.4,93.7) 156.67,93.98 PCG11.1 157.13,94.51 PRG02.1
  TOP w0.508: v1(145.77,111.69) 145.53,111.69 145.08,111.24 PRW11.1 ; v1(169.58,47.3) 169.66,47.23 v3(170.54,47.23) PRZ39.1 ; v1(164.79,89.02) 164.79,88.3 PCI31.1 165.45,88.12 165.91,87.66 167.2,87.66 v1(167.45,87.91) ; 78.71,130.42 79.35,131.06 PRV13.1 79.66,131 PCV12.1 80.74,131.42 81.12,131.8 82.6,131.8 83.54,130.86 v1(83.54,129.73) ; v1(48.61,47.49) 48.32,47.79 33.71,47.79 v1(33.12,48.38) ; v1(129.29,106.48) 128.72,105.91 121.89,105.91 119.03,108.77 v1(119.03,108.83) ; 93.44,60.07 90.49,57.11 87.82,57.11 86.27,55.56 v3(86.27,52.95) 86.27,48.62 80.76,43.11 79.2,43.11 74.58,38.5 74.58,33.84 73.31,32.57 72.49,32.57 ; PRI02.1 161.38,65.53 PCI11.1 v1(160.44,64.75) ; PR2504.1 69.55,115.37 69.08,114.91 67.17,114.91 v1(66.45,115.63) ; v1(42.71,126.68) 43.25,126.13 47.36,126.13 50.44,129.2 PD2.3 51.45,132.74 PD3.3 51.98,132.98 PR4.1
  TOP w2.032: 197.65,33.71 196,33.71 192.82,36.89
  IN1 w0.508: v1(23.11,38.93) 23.07,38.9 23.14,38.83 23.14,38.72 23.4,38.45 23.4,36.63 23.07,36.3 23.07,33.35 27.97,28.45 27.97,26.79 30.39,24.38 30.39,23.62 30.9,23.11 32.61,23.11 v1(32.67,23.17) ; v1(24.16,124.65) 23.85,124.33 23.85,122.68 21.37,120.2 21.37,114.99 24.46,111.9 v1(26.07,111.9) ; v1(83.54,129.73) 83.54,130.93 82.65,131.82 81,131.82 79.28,130.11 79.28,127.95 80.04,127.19 v1(80.55,127.19)
  IN2 w0.508: v1(66.45,115.63) 65.3,116.77 53.12,116.77 51.72,115.37 49.82,115.37 49.06,116.14 49.06,118.93 51.15,121.03 55.34,121.03 v1(57.82,123.5) ; v1(160.44,64.75) 160.57,64.75 162.26,66.44 v1(162.26,67.4) ; v1(71.92,31.94) 71.01,32.84 60.54,32.84 58.13,35.24 58.13,35.89 56.89,37.13 52.44,37.13 48.14,41.42 48.14,45.94 48.61,46.41 v1(48.61,47.49)
  BOTTOM w0.254: PUG01.15 156.51,93.6 v1(156.4,93.7) ; PUI02.15 165.22,88.6 v1(164.79,89.02) ; CZ30.1 118.64,107.72 118.64,108.38 119.03,108.77 v1(119.03,108.83) 119.03,109.55 ; PUI02.2 167.27,87.02 167.61,87.36 167.61,87.75 v1(167.45,87.91) 167.76,88.22 PRI22.1 ; PUI01.15 160.62,64.8 160.57,64.75 v1(160.44,64.75) ; UZ1.4 129.16,106.61 v1(129.29,106.48) 129.67,106.1 CZ1.1
  BOTTOM w0.305: v1(162.26,67.4) 162.52,67.14 PUI01.2
  BOTTOM w0.508: Q4.3 19.97,129.9 19.47,129.4 19.47,127.69 20.76,126.4 Q2.3 20.76,125.19 21.31,124.65 v1(24.16,124.65) ; v1(169.58,42.35) v1(169.58,47.3) 169.58,50.22 ; v1(165.67,41.37) 165.64,41.4 165.59,41.4 PRH11.1
  vias: v1(15.32,48.4) v1(15.32,47.77) v1(15.96,48.4) v1(15.96,47.77) v1(23.1,39.56) v1(23.73,39.57) v1(23.74,38.97) v1(26.21,111.27) v1(26.21,110.63) v1(26.8,111.9) v1(26.8,111.27) v1(26.8,110.63) v1(27.38,111.9) v1(27.38,111.27) v1(27.38,110.63) v1(28.02,111.9) v1(28.02,111.27) v1(28.02,110.63) v1(28.65,111.27) v1(28.65,110.63) v1(28.65,110) v1(29.29,111.27) v1(29.29,110.63) v1(29.29,110) v1(35.28,60.38) v1(35.28,59.75) v1(35.9,60.38) v1(35.9,59.77) v1(35.9,59.16) v1(35.91,58.54) v1(36.51,60.38) v1(36.51,59.77) v1(36.51,59.16) v1(37.12,60.38) v1(37.12,59.77) v1(37.12,59.16) v1(136.71,114.37) v1(137.17,113.93) v1(192.06,38.79) v1(192.44,38.29) v1(192.82,38.79) v1(193.2,38.29) v1(193.58,38.79) v1(199.04,33.84) v1(199.04,33.21) v1(199.68,33.84) v1(199.68,33.21) v1(200.31,33.46) v1(205.14,33.9) v1(205.71,34.22) v1(205.71,33.59) v1(206.35,34.22) v1(206.35,33.59) v3(193.76,38.04)
+5VALW_25810: length 8.5
  TOP w0.112: v1(29.75,114.87) v2(30.53,114.87)
  IN3 w0.508: v1(24.35,116.32) 24.53,116.14 28.48,116.14 v1(29.75,114.87)
  BOTTOM w0.508: RT3.1 RT2.1 24.56,116.52 v1(24.35,116.32)
+5VALW_VDD: length 3.7
  TOP w0.112: PR2504.2 v2(71.23,116.37)
  TOP w0.254: PU2501.4 71.92,114.23 72.17,114.49 PC2504.1 71.56,115.43 71.51,115.37 PR2504.2
+5VALWP: length 33.1
  IN2 w0.254: v1(28.09,107.51) 28.09,107.3 27.45,106.66 27.45,104.69 27.01,104.25 27.01,96.16 26.09,95.25 26.09,94.52 25.04,93.47 v1(23.28,93.47) ; v1(25.18,94.83) 25.18,95.14 26.63,96.59 26.63,104.43 27.03,104.83 27.03,106.89 27.46,107.31 v1(27.46,107.51)
  BOTTOM w0.254: PU501.14 25.11,95 25.18,94.93 v1(25.18,94.83) ; PR510.1 23.96,93.24 PR509.2 23.52,93.23 v1(23.28,93.47)
  vias: v1(17.18,105.81) v1(17.18,105.18) v1(17.18,104.54) v1(17.18,103.91) v1(21.51,105.7) v1(21.51,105.06) v1(21.51,104.43) v1(21.51,103.79) v1(22.11,105.39) v1(22.11,104.76) v1(22.11,104.12) v1(22.11,103.49) v1(24.93,108.14) v1(25.26,108.69) v1(25.55,108.14) v1(25.55,107.51) v1(26.19,108.75) v1(26.19,108.14) v1(26.19,107.51) v1(26.82,108.75) v1(26.82,108.14) v1(26.82,107.51) v1(27.46,108.75) v1(27.46,108.14) v1(28.09,108.75) v1(28.09,108.14) v1(28.73,108.75) v1(28.73,108.11) v3(23.83,108.17)
+5VS: length 257.3
  TOP w0.254: RB8.2 182.06,31.55
  TOP w0.508: v1(14.88,98.99) 15.33,98.54 FI1.2 ; QI1.2 24.01,93.81 23.48,94.34 v1(23.23,94.34) ; 59.66,25.4 58.52,25.4 57.12,26.79 57.12,29.46 58.28,30.62 Q12.3 ; 101.17,25.63 101.17,28.17 102.71,29.71 102.71,33.02 v1(102.9,33.21)
  TOP w2.032: 128.1,25.63 101.17,25.63 100.24,24.7 63.79,24.7 ; 150.46,25.74 150.46,25.74 175.6,25.74 181.2,31.34 181.2,31.87
  IN1 w0.508: v1(23.4,88.65) 23.4,89.91 22.69,90.62 22.69,93.8 v1(23.23,94.34)
  IN2 w0.508: v1(23.07,62.1) 23.07,63.17 24.55,64.64 24.55,75.62 22.26,77.91 22.26,86.55 23.4,87.69 v1(23.4,88.65) 23.1,88.96 19.08,88.96 18.88,88.76 17.64,88.76 15.97,90.42 15.97,93.52 14.88,94.61 v1(14.88,98.99)
  IN2 w2.032: 208.11,31.19 208.06,31.14 180.79,31.14 175.42,25.76 149.39,25.76
  IN3 w0.508: v1(23.07,62.1) 22.47,61.5 22.47,60.9 23.05,60.33 27.57,60.33 28.38,59.52 32.7,59.52 34.32,61.15 38.63,61.15 39.48,60.29 v1(39.48,59.75)
  BOTTOM w0.508: v1(102.9,33.21) 102.37,33.74 F3.2 ; v1(23.4,88.65) 23.45,88.7 DI1.1
  vias: v1(26.51,22.22) v1(27.15,22.22) v1(36.42,18.73) v1(36.42,18.09) v1(37.44,32.38) v1(37.75,32.89) v1(38.07,32.38) v1(38.39,32.89) v1(38.73,7.55) v1(38.73,6.92) v1(39.32,7.55) v1(39.32,6.92) v1(40.34,59.77) v1(40.42,60.38) v1(40.6,59.16) v1(40.92,59.77) v1(41.19,59.16) v1(41.5,59.77) v1(41.48,58.65) v1(41.81,59.18) v1(42.09,59.77) v1(42.06,58.65) v1(42.39,59.18) v1(58.49,24.5) v1(58.49,23.92) v1(59.12,24.5) v1(59.12,23.92) v1(59.76,24.5) v1(59.76,23.92) v1(60.39,24.5) v1(60.39,23.92) v1(61.03,24.5) v1(61.03,23.92) v1(61.66,24.5) v1(61.66,23.92) v1(62.3,24.5) v1(62.3,23.92) v1(136.94,25.84) v1(136.94,25.2) v1(146.21,25.78) v1(146.21,25.14) v1(184.59,70.81) v1(184.93,70.33) v1(185.25,69.83) v1(193.57,66.04) v1(194.15,66.04) v1(194.74,66.04) v1(195.32,66.04) v1(213.33,31.57) v1(213.97,31.57) v1(218.28,29.71) v1(218.92,29.71) v3(147.9,28.28)
+17.4V_BATT+: length 44.6
  IN2 w0.381: v1(210.28,44.53) 209.89,44.53 206.97,41.62 206.06,41.62 204.2,39.76 197.15,39.76 196.19,38.79 v1(194.47,38.79)
  IN3 w0.381: v1(194.47,38.79) 194.47,38.41 193.76,37.7 191.75,37.7 190.93,38.52 190.14,38.52 189.31,37.7 179.5,37.7 175.77,41.43 173.8,41.43 173.34,41.89 173.34,43.47
  BOTTOM w0.381: v1(210.28,44.53) 210.24,44.58 209.66,44.58 PRB35.1
  vias: v1(172.37,44.19) v1(173.01,44.19) v1(173.64,44.19) v1(174.28,44.19) v3(175.26,44.12)
+17.4V_BATT++: length 22
  TOP w0.112: v1(154.75,36.81) 154.75,37.69 v3(154.47,37.97) ; v1(154.75,36.81) v3(155.8,36.81) ; v1(154.75,36.81) 153.5,36.81 v3(153.32,36.63)
  BOTTOM w3.302: 156.5,34.6 171.61,34.6 173.78,36.78
+17.4V_BATT+_R: length 1.9
  TOP w0.112: v1(183.42,41.65) v2(183.42,40.95)
  TOP w0.508: v1(183.42,41.65) 183.83,42.06 PD14.2
+19V_ADPIN:
  vias: v1(83.73,142.43) v1(83.73,141.79) v1(83.73,141.16) v1(84.36,142.43) v1(84.36,141.79) v1(84.36,141.16) v1(85,142.43) v1(85,141.79) v1(85,141.16) v1(85.63,142.43) v1(85.63,141.79) v1(85.63,141.16) v3(84.5,140.25) v3(86.71,140.18) v3(87.3,141.97)
+19V_VIN: length 291.2
  TOP w0.254: 172.11,78.67 171.99,78.67 167.29,73.97 160.56,73.97 158.59,72 158.59,65.97 155.16,62.54 155.16,59.88 156.31,58.73 156.31,56.76 154.47,54.92 154.47,44.13 155.67,42.92 157.45,42.92 158.34,42.03 v1(158.34,36.76) ; v1(165.46,37.18) 165.46,37.01 164.94,36.5 164.94,34.86 164.68,34.59 PR36.1
  TOP w0.508: PRB09.1 200.69,47.94 200.5,48.13 PDB01.2 v1(201.33,49.07)
  TOP w2.54: 107.73,151.76 119.01,151.76 119.23,151.54 119.93,151.08 120,151.05 121.34,150.78 121.64,150.17 123.09,148.92 123.95,148.43 124.81,148.15 124.91,148.04 125.35,148.04 125.61,148.03 125.87,148 126.1,148.01 126.34,148 126.42,148.02 126.51,148.02 126.69,148.05 126.86,148.07 127.08,148.13 127.31,148.17 127.39,148.19 127.84,148.28 127.96,148.4 128.02,148.43 128.24,148.51 128.31,148.55 128.47,148.62 128.53,148.68 128.55,148.7 128.7,148.77 128.89,148.92 129.08,149.04 129.13,149.09 129.22,149.14 129.36,149.28 129.49,149.38 129.6,149.51 129.68,149.51 132.56,152.4 164.78,152.4 166.85,150.33 166.85,131.32 167.43,130.74 167.43,123.88 167.67,123.64 167.67,118.86 167.43,118.61
  IN3 w0.508: v1(211.3,50.41) 209.46,50.41 207.74,48.7 206.03,48.7 204.63,50.1 202.36,50.1 v1(201.33,49.07) 199.95,49.07 199.86,49.16 196.9,49.16 194.9,51.15 190.31,51.15 187.68,53.78 187.68,57.65 185.01,60.32 v1(185.01,60.76)
  BOTTOM w0.254: v1(165.46,37.18) 165.46,37.46 165.13,37.78 159.68,37.78 158.66,36.76 v1(158.34,36.76)
  BOTTOM w2.54: 134.72,150.93 137.6,150.93 138.93,152.26 164.85,152.26 166.85,150.26 166.85,131.31 167.43,130.74 167.43,124.24 168.06,123.61 168.06,120.01 ; 108.08,151.82 108.09,151.82 119.22,151.82 119.99,151.06 120.88,151.06 123.44,148.51 125.27,148.05 125.39,148.04 125.51,148.02 125.88,148.02 126.26,148 126.38,148.02 126.51,148.02 126.86,148.09 126.86,148.09 127.24,148.14 127.36,148.19 127.36,148.19 127.84,148.28 127.96,148.4 128.17,148.48 129.02,148.99 129.75,149.65 130.04,150.03 130.16,150.09 130.96,150.88 131.25,150.88
  vias: v1(85.63,147) v1(86.27,147) v1(86.9,147) v1(87.54,147) v1(87.54,146.36) v1(87.47,145.73) v1(88.17,147) v1(88.17,146.36) v1(88.17,145.73) v1(88.81,147) v1(88.81,146.36) v1(88.81,145.73) v1(163.74,116.52) v1(163.74,115.91) v1(163.74,115.3) v1(164.35,116.52) v1(164.35,115.91) v1(164.35,115.3) v1(164.96,116.52) v1(164.96,115.91) v1(164.96,115.3) v1(165.57,116.52) v1(165.57,115.91) v1(165.57,115.3) v1(169.96,101.72) v1(169.96,101.11) v1(169.96,100.5) v1(169.96,99.89) v1(169.96,99.28) v1(169.96,98.67) v1(170.57,101.72) v1(170.57,101.11) v1(170.57,100.5) v1(170.57,99.89) v1(170.57,99.28) v1(170.57,98.67) v1(177.05,77.74) v1(177.45,77.31) v1(177.87,76.89) v1(178.3,76.49) v1(178.74,76.08) v3(90.75,147.46)
+19VB: length 40.4
  TOP w0.508: PDB13.2 184.07,46.66 v1(184.95,45.78) ; v1(184.95,45.14) 184.39,44.59 PD14.3
  IN1 w1.016: 160.37,114.08 144.99,114.08 142.77,111.86 137.86,111.86 137.03,112.69
  BOTTOM w0.508: v1(17.17,46.55) 17.36,46.55 17.81,47.01 PR302.2
  BOTTOM w5.08: 33.18,103.69 39.28,109.79 39.28,112.96
  vias: v1(16.37,38.35) v1(16.37,37.77) v1(16.37,37.18) v1(16.37,36.6) v1(16.37,36.01) v1(16.98,38.35) v1(16.98,37.77) v1(16.98,37.18) v1(16.98,36.6) v1(16.98,36.01) v1(28.74,62.8) v1(28.74,62.16) v1(28.74,61.53) v1(28.74,60.89) v1(28.74,60.26) v1(29.37,62.8) v1(29.37,62.16) v1(29.37,61.53) v1(29.37,60.89) v1(29.37,60.26) v1(30.01,62.8) v1(30.01,62.16) v1(30.01,61.53) v1(30.01,60.89) v1(30.01,60.26) v1(47.92,24.3) v1(50.46,24.3) v1(50.58,138.87) v1(50.58,138.23) v1(51.1,24.3) v1(51.22,138.87) v1(51.22,138.23) v1(51.73,24.3) v1(51.85,138.87) v1(51.85,138.23) v1(52.49,138.87) v1(52.49,138.23) v1(53.12,138.87) v1(53.12,138.23) v1(90.34,141.42) v1(90.34,140.81) v1(90.34,140.2) v1(90.34,139.59) v1(90.34,138.98) v1(90.95,141.42) v1(90.95,140.81) v1(90.95,140.2) v1(90.95,139.59) v1(90.95,138.98) v1(134.42,112.6) v1(134.67,113.18) v1(135.05,112.6) v1(157.83,101.17) v1(157.83,100.53) v1(157.83,99.9) v1(158.46,101.17) v1(158.46,100.53) v1(158.46,99.9) v1(165.79,104.14) v1(165.79,103.51) v1(166.02,49.23) v1(166.02,48.6) v1(166.02,47.96) v1(166.42,104.14) v1(166.42,103.51) v1(167.06,104.14) v1(167.06,103.51) v1(167.6,56.57) v1(168.18,56.57) v1(168.77,56.57) v1(169.01,116.18) v1(169.01,115.55) v1(169.01,114.91) v1(169.33,116.71) v1(169.65,116.18) v1(169.65,115.55) v1(169.65,114.91) v1(172.88,77.53) v1(173.33,77.97) v1(173.26,77.08) v1(173.71,77.53) v1(173.71,76.64) v1(174.15,77.08) v1(174.15,76.2) v1(174.6,76.64) v1(174.6,75.81) v1(175.04,76.2) v1(185.58,45.78) v1(185.58,45.14) v1(186.22,45.78) v1(186.22,45.14) v1(186.85,45.78) v1(186.85,45.14) v1(187.49,45.78) v1(187.49,45.14) v1(192.69,49.4) v1(193.01,49.91) v1(193.33,49.4) v1(193.65,49.91) v1(193.96,50.41) v1(193.96,49.4) v1(194.28,49.91) v1(194.6,50.41) v1(194.6,49.4) v1(194.92,49.91) v1(200.05,66.94) v1(200.63,66.87) v1(200.63,66.28) v1(201.21,66.77) v1(201.21,66.19) v1(201.46,65.66) v1(201.79,66.72) v1(201.79,66.14) v1(202.37,66.67) v1(202.37,66.09) v1(208.57,53.74) v1(209.15,53.74) v1(209.74,53.74) v3(159.75,100.03)
+19VB_1.2V: length 10.9
  TOP w0.254: v1(32.17,27.8) 32.49,27.47 PRM07.1
  IN1 w0.254: 41.82,27.49 41.41,27.08 32.88,27.08 v1(32.17,27.8)
  vias: v1(41.89,28.32) v1(42.48,28.32) v1(43.06,28.32) v1(43.43,27.85) v2(44.2,27.01)
+19VB_1.05V: length 6.2
  TOP w0.112: v1(162.21,49.32) 162.21,50.07 v3(162.42,50.27)
  IN1 w0.508: v1(158.53,48.32) 158.53,48.7 159.15,49.32 v1(162.21,49.32)
  BOTTOM w0.508: v1(158.53,48.32) 158.53,48.9 PCH15.1
  vias: v1(162.59,48.83) v1(162.98,49.33)
+19VB_3V: length 0.6
  TOP w0.112: v1(18.2,40.95) v2(18.82,40.95)
  vias: v1(17.56,40.95)
+19VB_5V: length 1.7
  TOP w0.112: PC503.1 v3(30.6,99.08)
  vias: v1(28.62,99.88) v1(29.26,99.88)
+19VB_+1.35VGPU: length 1.5
  TOP w0.112: PCW03.1 v3(141.22,108.9)
  vias: v1(139.29,110.04) v1(140.05,110.04)
+19VB_CPU: length 46.4
  TOP w0.381: RB4.1 166.65,67.93 PCI23.1
  IN2 w0.124: 176.69,48.22 179.27,50.81 179.98,50.81 180.88,51.71 180.88,58.86 181.58,59.56 181.58,62.61 180.5,63.69 180.5,67.56 178.39,69.67 169.46,69.67 167.27,67.47 v1(167.27,66.54)
  IN2 w0.127: 176.69,48.22 176.69,47.39 176.09,46.79 175.1,46.79 174.66,47.24 172.37,47.24 v1(171.78,47.83)
  BOTTOM w0.254: PRZ35.1 171.74,47.87 v1(171.78,47.83)
  vias: v1(166.66,66.92) v1(167.12,82.12) v1(167.12,81.42) v1(167.12,80.78) v1(167.11,79.82) v1(167.11,79.12) v1(167.11,78.54) v1(167.11,77.95) v1(167.27,65.91) v1(167.62,83.68) v1(167.62,83.04) v1(167.64,79.52) v1(167.64,78.82) v1(167.64,78.23) v1(167.64,77.65) v3(168.64,80.37)
+19VB_DB: length 64.9
  TOP w0.203: v1(149.77,37.38) 149.77,37.38 149.77,35.65 150.15,35.26 v1(150.15,34.52) 149.55,35.11 v3(147.9,35.11) 146.59,35.11 143.98,37.72 v1(143.49,37.72)
  IN1 w0.203: v1(150.15,34.52) 150.69,33.97 151.17,33.97 153.99,36.8 153.99,38.63 155.3,39.94 163.61,39.94 164.63,40.95 164.63,42.1 166.11,43.59 167.04,43.59 167.39,43.59 168.05,44.25 168.05,45.53 167.55,46.03 167.55,48.06 167.55,48.07 167.55,48.27 168.69,49.41 168.69,53.15 169.58,54.03 v1(169.58,55.3)
  BOTTOM w0.203: RB12.1 169.96,58.17 170.21,57.92 170.21,55.56 169.96,55.3 v1(169.58,55.3) ; JDB1.20 147.81,34.2 148.9,34.2 149.12,33.98 149.94,33.98 150.15,34.19 v1(150.15,34.52) 150.15,34.72 149.87,35 JDB1.16 ; JDB1.2 148.9,37.8 149.01,37.9 149.56,37.9 149.77,37.7 v1(149.77,37.38) ; v1(143.49,37.72) 143.57,37.8 JDB1.1 145.86,37.8 146.08,37.57 146.08,35.2 145.88,35 JDB1.15
+19VB_VGA:
  vias: v1(81.71,125.59) v1(82.1,135.61) v1(82.3,125.59) v1(82.71,135.61) v1(83.01,125.59) v1(83.32,135.61) v1(83.35,124.2) v1(83.59,125.59) v1(83.93,135.61) v1(84.04,124.39) v1(84.04,123.76) v1(84.17,125.03) v1(84.54,135.61) v1(84.68,124.33) v1(85.34,138.29) v1(85.95,138.29) v1(86.56,138.29) v1(87.17,138.29) v1(87.78,138.29) v3(82.58,137.32)
+VCC_CORE: length 97.9
  TOP w0.508: v1(127.35,68.51) 127.35,68.89 PCI115.1 ; v1(128.62,68.51) 128.62,68.89 PCI116.1 ; PCI118.1 152.24,71.56 v1(152.24,71.18) ; v1(157.32,76) 157.32,76.39 PCI126.1 ; PCI114.1 126.08,68.89 v1(126.08,68.51) ; v1(128.49,75.75) 128.49,76.13 PCI124.1 ; PCI130.1 127.22,76.13 v1(127.22,75.75) ; PCI102.1 124.68,76.13 v1(124.68,75.75) ; PCI101.1 129.89,68.89 v1(129.89,68.51) ; PCI119.1 155.99,76.39 v1(155.99,76) ; PCI128.1 123.54,68.89 v1(123.54,68.51) ; PCI104.1 125.95,76.13 v1(125.95,75.75) ; PCI103.1 153.51,71.56 v1(153.51,71.18) ; PCI125.1 156.05,71.56 v1(156.05,71.18) ; v1(124.81,68.51) 124.81,68.89 PCI113.1 ; PCI120.1 157.32,71.56 v1(157.32,71.18) ; v1(154.78,71.18) 154.78,71.56 PCI108.1 ; v1(157.32,78.42) 157.32,78.8 PCI123.1 ; v1(155.99,78.42) 155.99,78.8 PCI129.1
  BOTTOM w0.076: 120.62,68.45 120.63,68.44 UC1.BB26 120.2,68.03
  BOTTOM w0.102: 120.82,66.01 UC1.BE26 ; UC1.BE26 120.83,66.41 ; UC1.BE26 120.4,65.98 ; UC1.BE26 120.38,66.45 ; 131.71,71.42 UC1.AU8 ; UC1.AU8 131.7,71.04 ; UC1.AU8 132.15,70.98 ; UC1.AU8 132.15,71.48 v1(132.15,71.69) 132.15,71.91 UC1.AR8 ; UC1.BE24 121.77,66.42 v1(121.77,66.66) ; UC1.BE24 121.35,66.41 ; UC1.BE24 121.35,66.01 ; UC1.BE24 121.77,65.99 v1(121.77,65.75) 121.77,65.51 UC1.BF24 ; 121.94,73.5 UC1.AN24 121.2,73.5 ; UC1.BF26 120.4,65.06 ; UC1.BF26 120.41,65.51 ; UC1.BF26 120.83,65.5 ; UC1.BF26 120.83,65.09 ; UC1.AV10 130.78,70.1 ; UC1.AV10 130.78,70.51 ; UC1.AV10 131.18,70.11 ; UC1.AV10 131.18,70.5 ; UC1.AP26 120.41,72.8 ; UC1.AP26 120.42,72.38 ; UC1.AP26 120.84,72.8 ; UC1.AP26 120.83,72.39 ; 131.69,69.59 UC1.AW8 ; UC1.AW8 131.69,69.18 ; UC1.AW8 132.15,69.13 v1(132.15,68.92) 132.15,68.71 UC1.BA8 ; 121.37,71.86 UC1.AT24 ; UC1.AT24 121.77,71.89 v1(121.77,72.13) 121.77,72.37 UC1.AP24 ; UC1.AT24 121.36,71.48 ; UC1.AT24 121.77,71.46 v1(121.77,71.22) 121.77,70.98 UC1.AU24 ; UC1.AR8 131.7,72.36 ; UC1.AR8 131.69,71.95 ; 131.24,69.64 UC1.AW9 ; UC1.AW9 131.64,69.65 ; UC1.AW9 131.24,70.05 ; UC1.AW9 131.64,70.04 ; UC1.AU24 121.61,70.7 121.87,70.7 ; UC1.AU24 121.42,70.63 121.21,70.63 ; UC1.AU24 121.35,70.96 ; 121.92,72.64 121.61,72.64 UC1.AP24 ; UC1.AW24 121.77,69.63 v1(121.77,69.4) 121.77,69.16 UC1.AY24 ; UC1.AW24 121.61,69.91 121.86,69.91 ; UC1.AW24 121.36,69.66 ; UC1.AW24 121.43,69.98 121.2,69.98 ; UC1.BE25 121.3,65.96 ; UC1.BE25 120.89,65.55 ; UC1.BE25 121.3,65.54 ; UC1.BE25 120.89,65.95 ; UC1.BE9 131.58,66.01 131.74,66.01 ; UC1.BE9 131.64,66.35 ; UC1.BE9 131.25,65.96 ; UC1.BE9 131.24,66.35 ; 131.25,65.42 UC1.BF9 ; UC1.BF9 131.66,65.44 ; UC1.BF9 131.38,65.17 131.16,65.17 ; UC1.BF24 121.5,65.24 121.17,65.24 ; UC1.BF24 121.35,65.49 ; UC1.BF24 121.61,65.24 121.92,65.24 ; UC1.AN9 131.33,73.65 131.11,73.65 ; UC1.AN9 131.62,73.37 131.62,73.25 ; UC1.AN9 131.23,73.33 ; UC1.AR25 120.9,72.32 ; UC1.AR25 121.29,72.33 ; UC1.AR25 120.9,71.94 ; UC1.AR25 121.29,71.93 ; UC1.AU26 120.42,70.56 ; UC1.AU26 120.82,70.96 ; UC1.AU26 120.41,70.98 ; UC1.AU26 120.84,70.55 ; 131.18,73.27 UC1.AN10 ; UC1.AN10 130.51,72.6 ; UC1.AN10 131.17,72.89 ; UC1.AN10 130.78,73.28 ; 120.83,66.91 UC1.BC26 ; UC1.BC26 120.4,67.34 ; UC1.BC26 120.4,66.89 ; UC1.BC26 120.84,67.33 ; 131.69,66.82 UC1.BD8 ; UC1.BD8 131.69,66.4 ; UC1.BD8 132.15,66.36 v1(132.15,66.15) ; UC1.AP24 121.43,72.71 121.2,72.71 ; UC1.AP24 121.35,72.38 ; UC1.BD25 121.29,66.46 ; UC1.BD25 120.89,66.87 ; UC1.BD25 120.88,66.45 ; UC1.BD25 121.33,66.9 ; 131.23,72.41 UC1.AP9 ; UC1.AP9 131.62,72.79 131.62,72.89 ; UC1.AP9 131.24,72.81 ; UC1.AP9 131.64,72.42 ; UC1.BA8 131.67,68.23 ; UC1.BA8 132.15,68.21 v1(132.15,68) ; UC1.BA8 131.67,68.69 ; UC1.AN26 120.7,73.58 121.02,73.58 ; UC1.AN26 120.4,73.27 ; UC1.AN26 120.85,73.28 ; 131.23,66.86 UC1.BC9 ; UC1.BC9 131.65,67.29 ; UC1.BC9 131.63,66.89 ; UC1.BC9 131.24,67.28 ; 120.4,68.72 UC1.AY26 ; UC1.AY26 120.82,69.13 ; UC1.AY26 120.41,69.16 ; UC1.AY26 120.82,68.74 ; 120.89,68.68 UC1.BA25 ; UC1.BA25 121.29,68.69 ; UC1.BA25 121.31,68.27 ; UC1.BA25 120.87,68.27 ; UC1.AY24 121.77,68.72 v1(121.77,68.48) ; UC1.AY24 121.36,68.74 ; UC1.AY24 121.35,69.14 ; UC1.AT9 131.64,71.89 ; UC1.AT9 131.24,71.49 ; UC1.AT9 131.23,71.9 ; UC1.AT9 131.64,71.49 ; 131.23,70.99 UC1.AU9 ; UC1.AU9 131.23,70.56 ; UC1.AU9 131.64,70.97 ; UC1.AU9 131.66,70.55 ; 121.28,71.03 UC1.AU25 ; UC1.AU25 120.89,71.42 ; UC1.AU25 121.28,71.41 ; UC1.AU25 120.9,71.03 ; 131.19,66.4 UC1.BD10 ; UC1.BD10 131.19,66.81 ; UC1.BD10 130.78,66.81 ; UC1.BD10 130.78,66.41 ; UC1.AT26 120.82,71.87 ; UC1.AT26 120.41,71.46 ; UC1.AT26 120.4,71.9 ; UC1.AT26 120.82,71.48 ; 130.78,69.59 UC1.AW10 ; UC1.AW10 131.21,69.16 ; UC1.AW10 130.76,69.16 ; UC1.AW10 131.18,69.58 ; 120.89,69.59 UC1.AW25 ; UC1.AW25 121.28,69.2 ; UC1.AW25 120.9,69.2 ; UC1.AW25 121.29,69.6 ; UC1.BC10 131.18,67.73 ; UC1.BC10 130.78,67.33 ; UC1.BC10 130.78,67.74 ; UC1.BC10 131.18,67.34 ; UC1.AW26 120.84,70.07 ; UC1.AW26 120.84,69.64 ; UC1.AW26 120.42,69.64 ; UC1.AW26 120.39,70.08 ; UC1.AR10 130.56,71.73 ; UC1.AR10 130.47,72.35 ; UC1.AR10 131.18,71.95 ; UC1.AR10 131.18,72.35
  BOTTOM w0.18: v1(137.7,67.56) 137.38,67.56 136.96,67.99 136.34,67.99 UC1.BB2 ; v1(137.08,70.58) 137.03,70.62 136.54,70.62 UC1.AV2 ; v1(137.07,65.78) 136.87,65.78 136.51,65.43 UC1.BF2 ; v1(137.08,72.86) 136.97,72.75 UC1.AP2
  BOTTOM w0.203: v1(132.78,71.69) UC1.AU6 v1(133.42,71.69) ; v1(132.78,71.69) UC1.AR7 ; v1(132.78,71.69) UC1.AU7 ; v1(132.78,71.69) UC1.AR6 v1(133.42,71.69) ; v1(133.42,71.69) UC1.AU5 v1(134.05,71.69) UC1.AR5 v1(133.42,71.69) ; UC1.BC7 v1(132.78,67.07) UC1.BC6 ; UC1.BC7 v1(132.15,68) ; UC1.BC7 v1(132.78,68) ; v1(133.42,67.07) UC1.BD5 ; v1(133.42,67.07) UC1.BC5 ; v1(133.42,67.07) UC1.BC6 ; v1(132.78,68.92) UC1.BA7 v1(132.78,68) ; v1(132.78,68.92) UC1.AW6 ; v1(132.78,68.92) UC1.AW7 ; v1(132.78,68) UC1.BC6 ; UC1.AW5 v1(134.05,68.92) UC1.BA5 v1(133.42,68.92) ; UC1.AW5 v1(133.42,69.85) ; UC1.AW5 v1(133.42,68.92) ; v1(133.42,69.85) UC1.AW6 ; v1(133.42,69.85) UC1.AV5 ; UC1.AW6 v1(133.42,68.92)
  BOTTOM w0.508: PCI125.1 156.05,71.56 v1(156.05,71.18) ; v1(157.32,78.42) 157.32,78.8 PCI123.1 ; v1(157.32,71.18) 157.32,71.56 PCI120.1 ; PCI119.1 155.99,76.39 v1(155.99,76) ; PCI108.1 154.78,71.56 v1(154.78,71.18) ; PCI129.1 155.99,78.8 v1(155.99,78.42) ; v1(157.32,76) 157.32,76.39 PCI126.1 ; v1(153.51,71.18) 153.51,71.56 PCI103.1
  vias: v1(119.83,68.95) v1(119.83,68.01) v1(119.87,72.59) v1(119.87,71.67) v1(119.87,70.76) v1(119.87,69.85) v1(119.87,67.12) v1(119.87,66.21) v1(119.87,65.29) v1(122.91,80.01) v1(122.91,66.42) v1(122.97,65.72) v1(123.54,80.01) v1(124.05,66.42) v1(124.11,79.69) v1(124.11,79.05) v1(124.11,78.42) v1(124.11,77.78) v1(124.11,77.15) v1(124.11,65.72) v1(125.19,66.42) v1(126.34,66.42) v1(127.48,66.42) v1(128.05,73.21) v1(128.05,72.32) v1(128.05,71.43) v1(128.05,70.54) v1(128.62,66.42) v1(129.76,66.42) v1(130.42,69.33) v1(130.42,67.76) v1(130.78,66.15) v1(130.78,65.23) v1(132.15,70.77) v1(132.78,70.77) v1(133.42,70.77) v1(134.05,70.77) v1(149.51,69.27) v1(149.51,68.64) v1(150.15,69.91) v1(150.15,69.27) v1(150.15,68.64) v1(150.53,70.54) v1(150.78,69.91) v1(150.78,69.27) v1(150.78,68.64) v1(150.78,65.46) v1(151.16,70.54) v1(151.26,84.94) v1(151.26,84.31) v1(151.26,83.67) v1(151.42,69.91) v1(151.42,69.27) v1(151.42,68.64) v1(151.42,65.46) v1(151.89,84.94) v1(151.89,84.31) v1(151.89,83.67) v1(152.05,69.27) v1(152.05,68.64) v1(152.05,65.46) v1(152.59,84.94) v1(152.59,84.31) v1(152.59,83.67) v1(152.59,83.04) v1(152.59,82.4) v1(152.59,81.77) v1(152.59,81.13) v1(152.59,80.5) v1(152.69,69.27) v1(152.69,68.64) v1(152.69,68) v1(152.69,67.37) v1(152.69,66.73) v1(152.69,66.1) v1(152.69,65.46) v1(153.23,84.94) v1(153.23,84.31) v1(153.23,83.67) v1(153.22,83.03) v1(153.23,82.4) v1(153.22,81.76) v1(153.22,81.13) v1(153.22,80.49) v1(153.32,69.27) v1(153.32,68.64) v1(153.32,68) v1(153.32,67.37) v1(153.32,66.73) v1(153.32,66.1) v1(153.32,65.46) v1(153.86,84.94) v1(153.86,84.31) v1(153.86,83.67) v1(153.85,83.03) v1(153.86,82.4) v1(153.85,81.76) v1(153.85,81.13) v1(153.85,80.49) v1(153.96,69.27) v1(153.96,68.64) v1(153.96,68) v1(153.96,67.37) v1(153.96,66.73) v1(153.96,66.1) v1(153.96,65.46) v1(154.5,84.94) v1(154.5,84.31) v1(154.5,83.67) v1(154.49,83.03) v1(154.5,82.4) v1(154.49,81.76) v1(154.49,81.13) v1(154.49,80.49) v1(154.59,69.27) v1(154.59,68.64) v1(154.59,68) v1(154.59,67.37) v1(154.59,66.73) v1(154.59,66.1) v1(154.59,65.46) v1(155.13,84.94) v1(155.13,84.31) v1(155.13,83.67) v1(155.12,83.03) v1(155.13,82.4) v1(155.12,81.76) v1(155.12,81.13) v1(155.12,80.49) v1(155.77,84.31) v1(155.77,83.67) v3(151.2,66.86)
