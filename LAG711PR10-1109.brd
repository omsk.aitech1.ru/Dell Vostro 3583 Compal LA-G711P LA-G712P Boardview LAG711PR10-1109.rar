# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_SPI_0_CS#2: length 63.8
  TOP w0.112: UX1.20 83.98,35.87 83.73,35.62 83.36,35.62 v1(83.14,35.4)
  IN3 w0.135: v1(117.45,50.68) 117.66,50.9 117.66,51.21 117.4,51.48 116.48,51.48 115.99,50.99 115.52,50.99 115.02,51.48 114.76,51.48 114.63,51.34 114.63,50.49 114.49,50.35 114.22,50.35 114.09,50.49 114.09,51.34 113.96,51.48 113.37,51.48 112.28,50.39 112.28,48.61 111.52,47.86 111.52,47.16 110.73,46.37 110.73,46.03 106.29,41.59 91.1,41.59 88.68,39.17 87.84,39.17 87.71,39.04 87.71,38.55 87.57,38.41 87.31,38.41 87.17,38.55 87.17,39.04 87.04,39.17 86.77,39.17 86.64,39.04 86.64,38.42 86.51,38.29 86.24,38.29 86.1,38.42 86.1,39.04 85.97,39.17 85.7,39.17 85.56,39.04 85.56,38.42 85.43,38.29 85.16,38.29 85.02,38.42 85.02,39.04 84.89,39.17 84.62,39.17 84.49,39.04 84.49,38.42 84.35,38.29 84.08,38.29 83.95,38.42 83.95,39.04 83.81,39.17 83.55,39.17 82.71,38.33 82.71,37.72 82.58,37.58 81.96,37.58 81.83,37.45 81.83,37.18 81.96,37.05 82.58,37.05 82.71,36.91 82.71,36.64 82.58,36.51 81.36,36.51 81.23,36.37 81.23,36.1 81.36,35.97 81.66,35.97 81.79,35.83 81.79,35.12 81.93,34.98 82.2,34.98 82.33,35.12 82.33,35.83 82.47,35.97 83.01,35.97 83.14,35.83 v1(83.14,35.4)
  BOTTOM w0.076: UC1.CH34 116.52,52.04 117.21,51.35 117.21,50.92 v1(117.45,50.68)
CPU_SPI_0_D0: length 26.5
  BOTTOM w0.076: 113.23,53.2 113.3,53.27 113.42,53.27 113.75,53.61 114.03,53.61 114.08,53.58 114.22,53.44 114.22,53.42 114.3,53.34 UC1.CF36
  BOTTOM w0.112: RC35.2 RC23.2 109,34.6 108.83,34.77 108.28,34.77 v2(107.62,35.42) 105.57,37.47 105.57,41.74 107.09,43.26 107.09,44.2 107.8,44.91 107.8,46.02 110.35,48.57 110.35,50.32 113.23,53.2
CPU_SPI_0_D1: length 24.7
  BOTTOM w0.102: 110.82,50.51 113.33,53.02 113.41,53.02 113.54,53.15 113.73,53.15 UC1.CF37
  BOTTOM w0.112: RC22.2 110.52,34.09 109.12,35.49 108.36,35.49 v2(106.48,37.37) 106.48,42.13 107.46,43.11 107.46,44.05 108.17,44.76 108.17,45.87 110.82,48.52 110.82,50.51
CPU_SPI_0_D2: length 27
  BOTTOM w0.076: UC1.CF34 115.87,52.62 115.59,52.34 115.11,52.34 114.89,52.11 114.89,51.81 114.68,51.6 114.68,51.32 114.25,50.89 114.25,50.87 113.91,50.54
  BOTTOM w0.102: 113.91,50.54 113.84,50.46 113.33,50.46 112.66,49.79 112.66,46.9
  BOTTOM w0.112: 112.66,46.9 112.22,46.46 112.22,46.13 111.94,45.85 111.94,45.58 110.44,44.08 v2(110.29,43.8) 109.15,41.62 109.08,41.46 108.76,40.59 108.76,38.56 109.04,38.28 109.04,37.49 111.03,35.49 112.61,35.49 112.66,35.49 113.45,35.49 114.33,34.6 RC24.2 RC36.2
CPU_SPI_0_D3: length 27.1
  BOTTOM w0.076: UC1.CG34 115.29,52.94 113.6,52.94 113.16,52.5 113.11,52.5
  BOTTOM w0.102: 113.11,52.5 111.28,50.67 111.28,48.47 110.8,47.98
  BOTTOM w0.112: 110.8,47.98 108.53,45.72 108.53,44.61 107.82,43.9 107.82,42.96 106.84,41.98 v2(106.84,39.75) 106.84,37.53 108.51,35.86 109.27,35.86 110.62,34.51 111.17,34.51 111.29,34.4 RC37.2 RC25.2
CPU_SPI_CLK: length 2.4
  BOTTOM w0.112: RC21.1 112.43,32.11 RC178.2 RC40.2 RX9.1
CPU_SPI_D0: length 4.2
  TOP w0.112: RC180.2 v1(109.13,32.44) 108.75,32.82 v2(108.73,32.82) ; RC180.2 RX6.1 ; RC180.2 RC42.2
  BOTTOM w0.112: v1(109.13,32.44) 109.13,33 RC23.1 RC32.2
CPU_SPI_D1: length 4
  TOP w0.112: v2(113.17,31.52) 112.86,31.82 RC43.2 RC179.2 RX5.1 110.65,32.36 v1(110.52,32.49)
  BOTTOM w0.112: v1(110.52,32.49) RC22.1
CPU_SPI_D2: length 2.3
  TOP w0.112: v1(114.46,32.52) 114.21,32.27 RC177.1
  BOTTOM w0.112: RC39.1 114.72,32.27 v1(114.46,32.52) 114.46,33 RC24.1
CPU_SPI_D3: length 2.3
  BOTTOM w0.112: RC181.1 RC41.1 111.92,32.01 111.92,32.57 112.05,32.69 RC25.1
CPU_XDP_TCK0: length 14.4
  TOP w0.112: RC156.1 139.29,84.96 138.12,86.13 134.54,86.13 133.47,85.06 v1(133.47,84.62) 133.39,84.62 132.91,85.1 TPC2.1
  BOTTOM w0.102: UC1.P6 v1(133.47,84.62) UC1.T6
CPVEE: length 5.3
  TOP w0.203: UA1.27 26.22,12.41 v2(25.98,12.18) 25.52,11.72 24.84,11.72 CA18.1
CS_1.2V: length 2.8
  TOP w0.203: PUM01.13 36.85,26.62 37.46,26.01 v2(37.8,26.01) 37.8,25.09 PRM03.1
CSCOMP_2PH_CPU: length 51.4
  TOP w0.254: v1(171.8,67.56) 171.67,67.69 171.67,70.8 170.77,71.7 v2(166.86,71.7) 160.7,71.7 160.05,71.05 160.05,70.18 v1(159.72,69.85)
  IN1 w0.254: v1(177.8,48.07) 177.7,48.17 177.7,52.38 179.17,53.84 179.17,57.83 178.33,58.67 178.33,60.31 179.86,61.84 179.86,63.62 177.92,65.57 172.45,65.57 171.8,66.21 v1(171.8,67.56)
  BOTTOM w0.203: PRZ27.2 177.43,49.29 PRZ28.1 176.3,49.56 PCZ18.1 PCZ17.1 176.29,50.69 175.63,51.36 PUZ01.6
  BOTTOM w0.254: PRZ27.2 177.43,48.44 v1(177.8,48.07) ; PHZ02.2 v1(159.72,69.85)
CSCOMP_2PH_CPU_R: length 45.6
  TOP w0.254: v1(160.64,69.85) 160.46,70.02 160.46,70.89 160.89,71.32 v2(162.48,71.32) 170.65,71.32 171.29,70.68 171.29,67.64 v1(171.22,67.56)
  IN1 w0.254: v1(171.22,67.56) 171.34,67.43 171.34,67.37 171.42,67.29 171.42,66.09 172.3,65.21 177.71,65.21 179.44,63.48 179.44,62.05 177.83,60.45 177.83,58.48 178.79,57.53 178.79,53.97 177.34,52.52 177.34,48.32 v1(177.08,48.06)
  BOTTOM w0.203: PRZ26.2 PRZ27.1 176.52,48.62 v1(177.08,48.06)
  BOTTOM w0.254: PHZ02.1 v1(160.64,69.85)
CSIN_CHG: length 6
  BOTTOM w0.112: PRB12.2 199.68,46.99 199.24,46.55 v2(197.9,46.55)
  BOTTOM w0.203: PUB01.14 201.68,46.12 201.41,46.4 PCB03.2 200.45,46.1 PCB05.1 PRB12.2
CSIP_CHG: length 5.2
  BOTTOM w0.112: PCB04.1 200.43,48.57 v2(200.76,48.24)
  BOTTOM w0.203: PUB01.15 201.84,46.52 201.05,47.32 PCB03.1 200.55,47.32 200.12,47.75 PRB11.2 PCB04.1
CSN1_VCORE1: length 7.7
  BOTTOM w0.112: PRZ31.1 161.58,68.66 v2(161.58,69.16)
  BOTTOM w0.254: PLI01.3 156.85,66.01 157.14,65.71 158.83,65.71 159.67,66.56 159.67,67.24 160.51,68.08 PRZ31.1
CSN2_VCORE2: length 13.5
  BOTTOM w0.254: PLI02.3 157.61,83.23 157.86,83.48 159.32,83.48 159.7,83.1 159.7,79.7 159.5,79.49 v2(159.5,78.66) 159.5,73.79 159.79,73.49 PRZ30.1
CSN_1A_VGT: length 54.3
  IN1 w0.152: v1(173.54,66.63) 173.92,66.63 174.34,67.05 174.34,71.75 169.42,76.67 169.42,91.79 164.5,96.71 160.89,96.71 158.39,99.21 158.23,99.21 158.2,99.25 157.44,99.25 157.15,98.96 v1(157.15,98.78)
  BOTTOM w0.152: v1(157.15,98.78) PHZ03.2 155,96 153.01,96 152.69,96.31 PLG01.3 ; PRZ51.1 173.5,63.6 173.9,64 173.9,66.27 v1(173.54,66.63)
CSN_1A_VGT_NTC: length 45.4
  IN1 w0.152: v1(173.77,68) 173.58,68.19 173.58,71.7 168.94,76.33 168.94,91.79 164.38,96.36 160.46,96.36 159.98,96.84 159.98,96.87 v1(158.07,98.78)
  BOTTOM w0.152: PRZ45.1 174.27,67.51 v1(173.77,68) ; v1(158.07,98.78) PHZ03.1
CSN_1B_VCCSA: length 44.3
  TOP w0.112: v1(156.13,49.72) v2(156.71,49.72)
  IN3 w0.152: v1(156.13,49.72) 154.97,50.87 154.97,54.82 155.84,55.68 158.64,55.68 159.52,56.57 160.23,56.57 161.06,57.4 168.63,57.4 170.25,59.02 175.79,59.02 176.46,58.35 180.12,58.35 181.12,57.35 v1(182.59,57.35)
  BOTTOM w0.152: PLA01.3 155.88,53.79 156.12,53.54 156.12,50.42 PHZ01.1 v1(156.13,49.72)
  BOTTOM w0.254: v1(182.59,57.35) 183.42,57.35 183.68,57.1 183.68,55.74 183.24,55.3 PRZ06.1
CSON_CHG: length 4.8
  TOP w0.203: PCB16.1 v1(206.54,42.81)
  BOTTOM w0.203: PUB01.1 206.03,43.13 206.35,42.81 v1(206.54,42.81) 206.54,42.78 206.85,42.46 v2(207.03,42.46) 207.29,42.46 207.5,42.68 207.5,43.14 PCB15.2 208.8,43.63 PRB37.1
CSOP_CHG: length 6
  TOP w0.112: v1(205.88,42.67) v2(205.88,42.16)
  TOP w0.203: PCB17.1 205.88,43.19 v1(205.88,42.67)
  BOTTOM w0.203: PUB01.2 205.63,42.92 v1(205.88,42.67) 206.59,41.96 207.54,41.96 208,42.41 PCB15.1 208.8,42.72 PRB36.1
CSP1_2PH_CPU: length 11.5
  TOP w0.112: PRZ32.2 v2(171.75,49.64)
  TOP w0.254: PRZ32.2 PCZ20.2 172.77,50.78 173.11,51.11 v1(173.29,51.11) ; PRZ37.2 174.39,46.78 v1(174.15,46.54)
  IN1 w0.254: v1(174.15,46.54) 174.91,47.3 174.91,49.49 v1(173.29,51.11)
  BOTTOM w0.203: PUZ01.10 174.03,51.51 173.62,51.11 v1(173.29,51.11)
CSP1_VCORE1: length 38.3
  TOP w0.254: PRZ25.1 176.5,48.8 176.5,47.75 176.31,47.56 ; 176.31,47.56 v2(176.31,47.05) 176.16,46.89 175.56,46.89 175.31,47.15 PRZ37.1 ; 176.31,47.56 v1(176.29,47.56)
  IN2 w0.152: v1(156.85,63.13) 156.18,62.46 156.18,55.53 155.85,55.2 155.85,52.37 158.19,50.03 169.74,50.03 170.43,49.34 174.49,49.34 175.29,48.53 175.29,47.94 175.78,47.45 176.19,47.45 v1(176.29,47.56)
  BOTTOM w0.254: PLI01.2 v1(156.85,63.13)
CSP2_2PH_CPU: length 7.2
  TOP w0.112: v1(173.47,48.92) 172.91,48.92 v2(172.49,48.5)
  TOP w0.254: v1(173.47,48.92) 173.58,48.82 PRZ39.2 173.66,48.06 PRZ38.2
  BOTTOM w0.203: PUZ01.9 174.43,51.42 PCZ21.2 PRZ33.2 v1(173.47,48.92)
CSP2_VCORE2: length 60
  TOP w0.254: v1(175.93,48.05) 175.82,47.94 175.43,47.94 PRZ38.1 175.31,48.45 175.12,48.63 PRZ29.1
  IN2 w0.152: v1(175.93,48.05) 175.81,48.05 175.55,48.31 175.55,48.64 174.59,49.6 170.54,49.6 169.85,50.29 158.29,50.29 156.1,52.48 156.1,55.1 156.43,55.43 156.43,61.78 157.26,62.61 157.26,64.64 158.58,65.96 158.58,85.61 158.33,85.86 v1(157.61,85.86)
  BOTTOM w0.152: PLI02.2 v1(157.61,85.86)
CSP_1A_VCORE: length 56.1
  TOP w0.152: v1(155.87,95.86) 155.73,96.01 v2(154.11,96.01) PRZ44.2 ; v1(173.77,67.37) 173.89,67.25 173.89,67.01 174.34,66.56 174.34,64.13 174.95,63.52 174.95,62.29 PCZ26.1
  TOP w0.254: PCZ26.1 174.41,61.74 174.41,60.37 v1(174.41,60.36)
  IN1 w0.152: v1(173.77,67.37) 173.33,67.81 173.33,71.29 168.56,76.06 168.56,91.75 164.31,96 160.46,96 159.87,96.59 156.55,96.59 155.87,95.91 v1(155.87,95.86)
  BOTTOM w0.203: PCZ27.1 174.41,61.18 v1(174.41,60.36) 174.41,59.96 174.83,59.54 PUZ01.29
  BOTTOM w0.254: PRZ45.2 174.35,62.04 PCZ27.1
CSP_1A_VGT_R: length 2.5
  TOP w0.112: v1(152.69,93.73) v2(152.69,93.16)
  TOP w0.152: PRZ44.1 152.56,93.87 v1(152.69,93.73)
  BOTTOM w0.152: PLG01.2 v1(152.69,93.73)
CSP_1B_VCCSA: length 32.9
  TOP w0.112: PRZ10.2 181.55,58.17 v1(181.84,57.88) ; v1(157.63,56.7) v2(157.63,57.39)
  TOP w0.152: PRZ13.2 v1(157.63,56.7)
  IN3 w0.152: v1(181.84,57.88) 181.46,58.26 180.91,58.26 178.96,60.22 177.07,60.22 176.75,59.89 169.99,59.89 168.23,58.13 161.08,58.13 160.02,57.07 158,57.07 v1(157.63,56.7)
  BOTTOM w0.152: PUZ01.40 179.16,56.9 179.32,57.06 180.26,57.06 PCZ08.2 PCZ09.2 181.84,57.75 v1(181.84,57.88)
CSP_1B_VCCSA_R: length 2.3
  TOP w0.112: v1(157.4,53.88) v2(157.4,53.27)
  TOP w0.152: v1(157.4,53.88) 157.4,54.4 PRZ13.1
  BOTTOM w0.152: PLA01.2 157.49,53.79 v1(157.4,53.88)
CSREF_2PH_CPU: length 41.3
  TOP w0.112: v1(161.83,69.91) v2(161.32,69.91)
  TOP w0.254: PCZ19.1 174.64,50.98 174.13,50.46 PCZ20.1 PRZ32.1 173.69,49.5 v1(174.25,48.94)
  IN1 w0.254: v1(174.25,48.94) 172.14,51.05 172.14,58.97 171.48,59.62 170.34,59.62 169.8,60.16 169.8,62.51 162.41,69.91 v1(161.83,69.91)
  BOTTOM w0.203: PUZ01.8 174.83,50.9 PCZ21.1 PRZ33.1 174.39,49.08 v1(174.25,48.94)
  BOTTOM w0.254: PRZ31.2 161.96,68.13 161.96,69.78 v1(161.83,69.91) 161.83,70.04 160.7,71.17 PRZ30.2
CSSUM_2PH_CPU: length 7.1
  TOP w0.112: v1(175.27,51.11) 175.58,51.42 v2(175.78,51.42)
  TOP w0.254: v1(175.27,51.11) 175.27,50.92 175.12,50.76 PRZ29.2 PRZ25.2
  BOTTOM w0.203: PUZ01.7 175.23,51.16 v1(175.27,51.11) 175.38,51.01 PCZ17.2 PCZ18.2 175.38,49.19 PRZ26.1
DAT_SMB: length 3.4
  TOP w0.112: v1(162.72,41.21) 162.72,41.57 162.83,41.68 v2(163.06,41.68) 163.22,41.52 163.22,40.94 162.98,40.7 PR37.1
  BOTTOM w0.112: PBATT1.6 163.01,40.92 v1(162.72,41.21)
DAT_TP_SIO: length 153.1
  TOP w0.112: v1(44.01,81.73) 44.06,81.68 44.27,81.68 44.34,81.76 44.34,82.03 44.27,82.1 44.27,82.47 44.15,82.58 UE1.79 ; C24.1 127.53,28.97 127.16,28.61 126.64,28.61 v4(125.45,29.79) 125.31,29.94 124.66,29.94 124.63,29.9 124.63,29.9 v1(124.25,29.53) 124.35,29.43 124.35,29.07 R34.2
  IN3 w0.135: v1(44.01,81.73) 44.22,81.94 44.22,82.13 44.01,82.33 43.71,82.33 43.26,81.88 43.26,75.42 40.08,72.23 40.08,68.55 38.22,66.69 38.22,66.15 38.39,65.97 38.9,65.97 39.43,65.44 39.43,64.28 41.04,62.67 41.69,62.67 43.92,60.44 43.92,58.3 42.08,56.45 42.08,54.94 40.94,53.8 40.94,46.84 41.89,45.89 41.89,39.13 44.55,36.48 44.55,36.31 44.72,36.13 44.98,36.13 v1(45.1,36.25)
  BOTTOM w0.112: JTP1.2 124.05,29.8 124.25,29.6 v1(124.25,29.53) 124.38,29.39 124.38,28.8 121.23,25.64 99.82,25.64 98.87,24.69 64.02,24.69 62.86,25.86 58.22,25.86 57.68,26.4 57.68,30.83 53.72,34.78 47.18,34.78 46.06,35.91 45.45,35.91 v1(45.1,36.25)
DBC_PANEL_EN: length 171.8
  TOP w0.112: v1(117.95,55.24) 117.55,54.84 116.93,54.84 116.69,55.08 v2(115.07,55.08) 111.67,55.08 109.54,52.95 109.54,51.59 107.28,49.33 RC106.2 ; R13.1 211.12,55.11 210.78,55.46 210.78,55.95 v1(210.45,56.28)
  IN1 w0.119: v1(210.45,56.28) 208.83,54.67 205.79,54.67 204.45,53.32 204.45,50.66 204.76,50.35 207.36,50.35 209.11,48.59 209.11,46.88 211.07,44.92 211.68,44.92 212.13,44.47 212.13,35.55 210.88,34.3 207.61,34.3 205.65,32.34 181.13,32.34 176.1,27.3 v1(175.05,27.3)
  IN3 w0.089: 130.86,51.96 130.86,51.97 130.86,52.37 130.46,52.76 130.14,52.76 129.89,53.02 129.89,53.2 128.59,54.51 128.59,55.8 128.2,56.19 125.63,56.19 125.63,56.18 124.86,56.95 123.95,56.95 123.61,56.61 123.61,56.27 122.13,54.8 118.4,54.8 v1(117.95,55.24)
  IN3 w0.135: 130.86,51.96 130.86,50.19 131.65,49.4 133.74,49.4 133.87,49.26 133.87,46.24 134.45,45.67 135.68,45.67 135.82,45.52 135.82,43.04 134.06,41.27 134.06,38.4 135.95,36.51 140.15,36.51 140.39,36.75 142.24,36.75 144.69,34.31 144.69,33.53 149.19,29.03 157.36,29.03 158.36,30.03 163.56,30.03 164.17,29.42 168.97,29.42 170.5,27.89 171.51,27.89 172.1,27.3 v1(175.05,27.3)
  BOTTOM w0.076: v1(117.95,55.24) 117.56,55.63 UC1.CA31
DBC_PANEL_EN_R: length 2.8
  TOP w0.112: v2(212.67,54.2) R13.2 212.94,55.11 v1(213.36,55.53)
  BOTTOM w0.112: JEDP1.11 213.28,55.45 v1(213.36,55.53)
DCIN_CHG:
  vias: v2(202.03,48.61)
DDR_A_ACT#: length 53.7
  IN1 w0.089: v1(111.03,83.62) 110.14,83.62 109.7,84.07 109.7,84.58 109,85.28 105.7,85.28 102.61,88.37 102.4,88.37
  IN1 w0.147: v1(73.47,84.16) 73.28,84.16 72.88,83.75 72.63,83.75 72.49,83.61 72.49,82.63 72.63,82.48 73.36,82.48 73.78,82.9 83.73,82.9 88.22,87.39 92.02,87.39 93,88.37 102.4,88.37
  BOTTOM w0.076: v1(111.03,83.62) 111.71,83.62 112.55,83.28 112.63,83.27 112.78,83.19 112.97,83.11 114.04,83.11 114.15,83.15 114.32,83.15 114.46,83.1 114.68,83.1 UC1.V35
  BOTTOM w0.14: v1(73.47,84.16) 73.47,83.17 72.04,81.74 JDIMM1.114
DDR_A_ALERT#: length 50.1
  IN1 w0.089: v1(109.29,84.23) 109.29,83.85 109.2,83.76 108.68,83.76 108.32,84.12 108.32,84.45 108.56,84.7 108.56,84.8 108.35,85 108.23,85 108.01,84.79 107.88,84.79 107.73,84.94 105.77,84.94 102.75,87.95 102.52,87.95
  IN1 w0.147: v1(73.51,81.64) 73.51,82.04 73.95,82.49 83.9,82.49 88.39,86.98 92.2,86.98 93.17,87.95 102.52,87.95
  BOTTOM w0.076: v1(109.29,84.23) 109.55,83.96 109.78,83.96 111.6,82.14 112.86,82.14 113.07,82.36 113.8,82.36 UC1.W37
  BOTTOM w0.14: v1(73.51,81.64) 73.07,81.2 72.25,81.2 72.21,81.24 JDIMM1.116
DDR_A_BA0: length 51.1
  IN1 w0.089: v1(116.63,82.68) 115.34,81.98 112.82,80.06 112.62,79.94 111.37,79.43 111.03,79.18 110.32,78.74 110.12,78.66 104.31,78.66 103.91,79.06 103.37,79.06
  IN1 w0.147: 103.37,79.06 90.99,79.06 84.67,72.75 75.42,72.75 v1(74.97,72.3)
  BOTTOM w0.102: v1(116.63,82.68) 116.69,82.61 116.69,82.59 116.72,82.56 UC1.W32
  BOTTOM w0.14: v1(74.97,72.3) 73.88,71.21 72.48,71.21 72,70.74 70.95,70.74 JDIMM1.150
DDR_A_BA1: length 52.9
  IN1 w0.089: 104.09,77.81 104.7,77.81 104.83,77.93 111.81,77.93 112.14,78.26 113.62,78.26 116.57,81.21 117.32,81.21 117.43,81.1 117.43,80.9 v1(117.33,80.8)
  IN1 w0.147: 104.09,77.81 103.69,77.41 91.67,77.41 85.36,71.09 82.26,71.09 82.11,70.94 82.11,70.65 81.96,70.5 81.67,70.5 81.52,70.65 81.52,70.94 81.37,71.09 81.08,71.09 80.93,70.94 80.93,70.65 80.78,70.5 80.49,70.5 80.34,70.65 80.34,70.94 80.2,71.09 79.9,71.09 79.75,70.94 79.75,70.65 79.61,70.5 79.31,70.5 79.16,70.65 79.16,70.94 79.02,71.09 78.72,71.09 78.57,70.94 78.57,70.65 78.43,70.5 78.13,70.5 77.99,70.65 77.99,70.94 77.84,71.09 77.16,71.09 76.75,70.67 v1(76.56,70.67)
  BOTTOM w0.089: v1(117.33,80.8) 117.33,80.79 UC1.AB31
  BOTTOM w0.14: JDIMM1.145 77.3,71.99 76.56,71.25 v1(76.56,70.67)
DDR_A_BG0: length 53.5
  IN1 w0.089: 102.14,88.78 102.44,88.78 105.72,85.51 109.02,85.51 109.89,84.64 109.89,84.2 110.08,84.01 111.69,84.01 111.95,83.75 v1(111.95,82.91)
  IN1 w0.147: v1(74.99,84.16) 74.8,84.16 74.41,83.76 74.41,83.46 74.56,83.31 83.56,83.31 88.05,87.8 91.85,87.8 92.83,88.78 102.14,88.78
  BOTTOM w0.076: v1(111.95,82.91) 111.95,82.7 112.14,82.51 112.76,82.51 112.95,82.7 113.95,82.7 114.15,82.63 114.32,82.63 114.43,82.67 114.44,82.67 114.45,82.67 114.69,82.67 114.81,82.63 115.28,82.63 UC1.V34
  BOTTOM w0.14: JDIMM1.115 79.15,81.49 78.09,81.49 76.35,83.23 75.92,83.23 v1(74.99,84.16)
DDR_A_BG1: length 54
  IN1 w0.089: 102.28,89.2 105.79,85.68 109.48,85.68 110.27,84.89 v1(110.27,84.39)
  IN1 w0.147: 102.28,89.2 91.24,89.2 91.09,89.05 91.09,88.36 90.94,88.22 90.65,88.22 90.5,88.36 90.5,89.05 90.35,89.2 90.06,89.2 89.91,89.05 89.91,88.36 89.76,88.22 89.47,88.22 89.32,88.36 89.32,89.05 89.17,89.2 88.85,89.2 83.39,83.73 83.04,83.73 82.89,83.87 82.89,84.01 82.75,84.16 82.45,84.16 82.3,84.01 82.3,83.87 82.16,83.73 81.86,83.73 81.72,83.87 81.72,84.01 81.57,84.16 81.27,84.16 81.13,84.01 81.13,83.87 80.98,83.73 79.75,83.73 79.6,83.87 79.6,84.01 79.45,84.16 79.16,84.16 79.01,84.01 79.01,83.87 78.86,83.73 78.57,83.73 78.42,83.87 78.42,84.01 78.27,84.16 77.98,84.16 77.83,84.01 77.83,83.87 77.68,83.73 76.66,83.73 76.51,83.87 76.51,84.15 v1(76.52,84.16)
  BOTTOM w0.076: v1(110.27,84.39) 110.27,83.73 111.65,82.35 112.83,82.35 113,82.52 113.96,82.52 114.12,82.46 114.36,82.46 114.48,82.51 114.66,82.51 115.12,82.34 UC1.W35
  BOTTOM w0.14: v1(76.52,84.16) 76.52,84.15 76.52,83.74 78.28,81.99 79.15,81.99 JDIMM1.113
DDR_A_CAS#: length 53.4
  IN1 w0.089: v1(116.68,80.8) 116.48,80.8 114.91,79.23 114.91,79.02 113.38,77.49 112.27,77.49 112.02,77.75 104.9,77.75 104.54,77.39 104.01,77.39
  IN1 w0.147: 104.01,77.39 103.61,76.99 91.85,76.99 85.53,70.68 82.72,70.68 82.14,70.09 75.61,70.09 75.47,70.23 75.47,70.43 75.27,70.63 74.99,70.63 74.45,70.09 73.96,70.09 73.85,70.19 73.85,70.46 74.06,70.67 v1(74.27,70.67)
  BOTTOM w0.102: UC1.AB32 116.7,80.77 116.7,80.78 v1(116.68,80.8)
  BOTTOM w0.14: JDIMM1.156 70.95,69.24 71.96,69.24 72.23,69.51 73.1,69.51 v1(74.27,70.67)
DDR_A_CKE0: length 57.5
  IN1 w0.147: v1(105.19,87.31) 105.19,87.43 102.36,90.26 88.41,90.26 84.95,86.8 83.39,86.8 83.24,86.65 83.24,85.37 83.09,85.23 82.8,85.23 82.65,85.37 82.65,86.65 82.51,86.8 82.21,86.8 82.07,86.65 82.07,85.37 81.92,85.23 81.62,85.23 81.48,85.37 81.48,86.65 81.33,86.8 81.03,86.8 80.89,86.65 80.89,85.37 80.74,85.23 80.45,85.23 80.3,85.37 80.3,86.65 80.15,86.8 77.69,86.8 77.55,86.65 77.55,86.25 77.4,86.1 77.1,86.1 76.96,86.25 76.96,86.65 76.81,86.8 76.49,86.8 76.3,86.61 76.3,85.8 76.44,85.66 v1(76.68,85.66)
  BOTTOM w0.076: UC1.U36 114.51,83.54 114.05,83.8 113.77,83.8 113.59,83.62 113.12,83.62 112.7,84.04 111.99,84.04 111.01,84.64 110.03,85.06 108.54,85.06
  BOTTOM w0.127: 108.54,85.06 106.45,87.15
  BOTTOM w0.14: v1(76.68,85.66) 77.91,84.43 77.91,83.28 78.19,82.99 JDIMM1.109 ; 106.45,87.15 106.29,87.31 v1(105.19,87.31)
DDR_A_CKE1: length 56.1
  IN1 w0.147: v1(105.78,86.66) 105.78,86.65 105.27,86.65 104.3,87.63 104.3,87.69 102.14,89.85 88.58,89.85 83.54,84.81 80.03,84.81 79.88,84.96 79.88,86.21 79.74,86.36 79.44,86.36 79.29,86.21 79.29,84.96 79.15,84.81 78.85,84.81 78.71,84.96 78.71,86.21 78.56,86.36 78.26,86.36 78.12,86.21 78.12,84.96 77.97,84.81 74.48,84.81 v1(73.64,85.66)
  BOTTOM w0.076: UC1.U37 113.69,83.47 113.62,83.45 113.05,83.45 112.84,83.67 111.93,83.89 110.94,84.5 110.19,84.82 108.4,84.82 106.79,85.13 106.45,85.35
  BOTTOM w0.14: 106.45,85.35 105.98,85.66 105.74,85.9 105.74,86.62 v1(105.78,86.66) ; v1(73.64,85.66) 73.24,85.26 72.4,85.26 72.14,85 72.14,82.97 71.9,82.74 JDIMM1.110
DDR_A_CKE2: length 6.9
  BOTTOM w0.076: UC1.U34 115.69,83.54 115.39,83.84 114.31,83.84 114.09,83.96 113.7,83.96 113.52,83.78 113.19,83.78 112.76,84.2 112.04,84.2 110.19,85.34 TP9.1
DDR_A_CKE3: length 4.7
  BOTTOM w0.076: UC1.U35 115.01,83.54 114.74,83.27 114.5,83.27 114.35,83.32 114.12,83.32 114.04,83.29 113.77,83.29 113.77,83.29 112.97,83.29 112.24,83.62 112.14,83.62 111.85,83.74 111.11,84.2 TP11.1
DDR_A_CLK0: length 55.1
  IN1 w0.089: 103.47,79.55 103.6,79.43 109.83,79.43 110.29,79.89 111,79.89 113.53,82.42 115.75,82.42 116.37,83.05 116.74,83.05 116.91,83.23 v1(117.33,83.52)
  IN1 w0.119: 103.47,79.55 103.21,79.81 102.11,79.81 101.95,79.98 101.18,79.98 101.02,79.81 96.9,79.81 96.65,80.06 96.65,80.11 96.53,80.23 96.17,80.23 96.05,80.11 96.05,80.06 95.81,79.81 95.3,79.81 94.88,80.23 94.52,80.23 94.4,80.11 94.4,80.06 94.16,79.81 93.62,79.81 93.37,80.06 93.37,80.11 93.25,80.23 92.89,80.23 92.77,80.11 92.77,80.06 92.53,79.81 90.83,79.81 84.4,73.39 78.88,73.39 78.65,73.62 78.65,73.73 78.54,73.84 78.19,73.84 78.08,73.73 78.08,73.62 77.84,73.39 76.58,73.39 76.32,73.64 76.32,73.81 v1(76.11,74.02)
  BOTTOM w0.102: UC1.V31 v1(117.33,83.52)
  BOTTOM w0.112: JDIMM1.137 78.12,75.99 77.98,75.85 75.39,75.85 75.12,75.59 75.12,74.95 75.43,74.64 76.08,74.64 76.23,74.49 76.23,74.15 v1(76.11,74.02)
DDR_A_CLK1: length 53.9
  IN1 w0.089: 102.14,81.08 103.04,81.08 104.34,79.78 109.44,79.78 111.26,81.6 112.14,81.6 114.13,83.58 116.01,83.58 116.32,83.89 116.9,83.89 117.07,84.07 117.07,84.28 117.22,84.43 v1(117.3,84.43)
  IN1 w0.119: 102.14,81.08 102.13,81.08 102.13,81.08 90.9,81.08 84.5,74.69 74.96,74.69 74.84,74.57 v1(74.84,74.02)
  BOTTOM w0.089: v1(117.3,84.43) 117.33,84.43 UC1.T31
  BOTTOM w0.112: JDIMM1.138 72.05,75.74 72.17,75.62 74.04,75.62 74.55,75.12 74.55,74.31 v1(74.84,74.02)
DDR_A_CLK#0: length 55.1
  IN1 w0.089: 103.53,79.81 103.73,79.6 109.75,79.6 110.23,80.08 110.93,80.08 113.46,82.61 114.31,82.61 114.4,82.7 114.4,83.16 114.49,83.24 114.65,83.24 114.74,83.16 114.74,82.7 114.83,82.61 115.67,82.61 116.3,83.24 116.66,83.24 116.77,83.35 116.77,83.43 v1(116.68,83.52)
  IN1 w0.119: 103.53,79.81 103.3,80.03 102.2,80.03 102.04,80.2 101.09,80.2 100.93,80.03 96.99,80.03 96.87,80.15 96.87,80.21 96.62,80.45 96.08,80.45 95.84,80.21 95.84,80.15 95.72,80.03 95.39,80.03 94.97,80.45 94.43,80.45 94.19,80.21 94.19,80.15 94.07,80.03 93.71,80.03 93.59,80.15 93.59,80.21 93.34,80.45 92.8,80.45 92.56,80.21 92.56,80.15 92.44,80.03 90.74,80.03 84.31,73.61 78.97,73.61 78.87,73.71 78.87,73.82 78.63,74.06 78.09,74.06 77.86,73.82 77.86,73.71 77.75,73.61 76.67,73.61 76.54,73.73 76.54,73.9 76.66,74.02 v1(76.74,74.02)
  BOTTOM w0.102: UC1.V32 116.71,83.49 v1(116.68,83.52)
  BOTTOM w0.112: v1(76.74,74.02) 76.46,74.31 76.46,74.58 76.17,74.86 75.52,74.86 75.35,75.04 75.35,75.5 75.48,75.63 77.98,75.63 78.12,75.49 JDIMM1.139
DDR_A_CLK#1: length 53.8
  IN1 w0.089: v1(116.66,84.45) 116.73,84.45 116.89,84.29 116.89,84.14 116.82,84.07 116.23,84.07 115.93,83.77 114.05,83.77 112.07,81.78 111.18,81.78 109.35,79.96 104.41,79.96 103.1,81.27 102.21,81.27 102.18,81.3 102.14,81.3
  IN1 w0.119: 102.14,81.3 90.81,81.3 84.41,74.9 74.87,74.9 74.62,74.66 74.62,74.44 v1(74.2,74.02)
  BOTTOM w0.102: v1(116.66,84.45) 116.67,84.45 116.91,84.21 UC1.T32
  BOTTOM w0.112: JDIMM1.140 72.01,75.24 72.17,75.4 73.95,75.4 74.32,75.03 74.32,74.14 v1(74.2,74.02)
DDR_A_CS#0: length 57.5
  IN1 w0.089: 103.51,75.51 103.64,75.51 104.02,75.89 104.02,76.02 104.69,76.69 106.52,76.69 106.73,76.48 110.58,76.48 110.67,76.57 110.67,77.06 110.76,77.15 110.93,77.15 111.02,77.06 111.02,76.57 111.11,76.48 111.29,76.48 111.38,76.57 111.38,77.06 111.47,77.15 111.64,77.15 111.73,77.06 111.73,76.57 111.82,76.48 112.75,76.48 113.03,76.2 113.56,76.2 113.86,76.5 113.86,77 115.13,78.27 116.02,78.27 116.67,78.92 v1(116.67,78.97)
  IN1 w0.147: 103.51,75.51 92.46,75.51 89.35,72.39 89.35,71.8 89.13,71.58 88.92,71.58 88.83,71.67 88.62,71.67 88.38,71.43 88.38,71.22 88.47,71.13 88.47,70.92 88.27,70.72 88.06,70.72 87.97,70.81 87.76,70.81 87.55,70.6 87.55,70.39 87.64,70.3 87.64,70.09 87.43,69.88 87.22,69.88 87.13,69.97 86.92,69.97 86.72,69.76 86.72,69.56 86.81,69.47 86.81,69.26 86.6,69.05 86.39,69.05 86.3,69.14 86.09,69.14 85.88,68.93 85.88,68.72 85.97,68.63 85.97,68.42 85.76,68.21 85.56,68.21 85.46,68.31 85.26,68.31 84.96,68.01 82.12,68.01 81.8,68.32 79.77,68.32 79.62,68.47 79.62,68.87 79.48,69.02 79.18,69.02 79.03,68.87 79.03,68.47 78.89,68.32 78.59,68.32 78.45,68.47 78.45,68.87 78.3,69.02 78,69.02 77.86,68.87 77.86,68.47 77.71,68.32 76.42,68.32 76.27,68.47 76.27,68.78 v1(76.56,69.06)
  BOTTOM w0.102: v1(116.67,78.97) 116.72,78.91 116.9,78.54 UC1.AE32
  BOTTOM w0.14: v1(76.56,69.06) 77.89,70.39 77.89,70.67 78.2,70.99 JDIMM1.149
DDR_A_CS#1: length 57.8
  IN1 w0.089: 103.51,74.68 105.1,76.27 106.27,76.27 106.46,76.07 112.41,76.07 113,75.48 113.48,75.48 115.03,77.03 115.03,77.67 115.26,77.89 116.52,77.89 v1(116.68,78.05)
  IN1 w0.147: 103.51,74.68 92.8,74.68 90.17,72.05 90.17,71.45 85.9,67.18 81.77,67.18 81.46,67.5 75.12,67.5 75.03,67.4 73.6,67.4 73.31,67.11 73.31,66.42 73.5,66.23 74.05,66.23 v1(74.73,66.91)
  BOTTOM w0.102: UC1.AF32 116.73,77.98 116.7,78.01 116.7,78.03 v1(116.68,78.05)
  BOTTOM w0.14: JDIMM1.157 78.38,68.99 77.53,68.13 75.95,68.13 v1(74.73,66.91)
DDR_A_D0: length 64.7
  IN1 w0.119: v1(121.28,97.5) 122.17,96.61 122.17,94.46 119.8,92.09 113.61,92.09 111.36,94.34 107.1,94.34 103.05,98.39 86.6,98.39 85.24,99.75 73.25,99.75 72.75,100.26 v1(72.75,100.73)
  BOTTOM w0.076: v1(121.28,97.5) 120.74,96.95 120.74,94.38 120.89,94.22 120.89,93.64 120.74,93.49 120.74,92.91 120.83,92.82 UC1.A26
  BOTTOM w0.112: v1(72.75,100.73) 70.96,100.73 JDIMM1.38
DDR_A_D1: length 65.7
  IN1 w0.089: v1(120.03,94.55) 119.85,94.37 113.24,94.37 112.56,95.05 107.71,95.05 107.6,95.16
  IN1 w0.119: 107.6,95.16 103.4,99.36 88.12,99.36 87.85,99.63 87.85,99.7 87.73,99.82 87.49,99.82 87.37,99.7 87.37,99.63 87.26,99.51 86.85,99.51 86.48,99.88 86.48,100.05 87.16,100.73 87.16,100.89 86.99,101.06 86.82,101.06 86.15,100.39 85.98,100.39 85.81,100.56 85.81,100.73 86.48,101.4 86.48,101.57 86.31,101.74 86.15,101.74 85.47,101.06 85.3,101.06 84.46,101.91 83.05,101.91 82.93,101.79 82.93,101.58 82.81,101.46 82.57,101.46 82.45,101.58 82.45,101.79 82.33,101.91 81.31,101.91 80.87,101.47 79.9,101.47 79.78,101.59 79.78,101.79 79.66,101.91 79.43,101.91 79.31,101.79 79.31,101.59 79.19,101.47 78.95,101.47 78.83,101.59 78.83,101.79 78.71,101.91 78.47,101.91 78.35,101.79 78.35,101.59 78.23,101.47 77.32,101.47 76.97,101.12 76.45,101.12 76.33,101.24 76.33,101.51 76.21,101.63 74.95,101.63 74.8,101.47 74.8,101.27 74.92,101.15 75.61,101.15 75.79,100.97 v1(75.79,100.73)
  BOTTOM w0.076: v1(120.03,94.55) 120.03,94.32 119.87,94.17 119.8,94.1 119.8,93.78 119.96,93.62 119.96,92.5 119.92,92.39 119.92,92.21 119.96,92.09 119.96,91.85 119.89,91.66 119.89,90.88 119.89,90.88 120.06,90.71 120.06,90.71 120.1,90.67 UC1.D26
  BOTTOM w0.112: v1(75.79,100.73) 76.54,99.99 79.15,99.99 JDIMM1.41
DDR_A_D2: length 66.3
  IN1 w0.089: v1(119.37,99.13) 119.37,98.19 118.76,97.58 118.76,96.05 118.27,95.56 114.39,95.56 113.37,96.59 109.34,96.59 108.34,97.59
  IN1 w0.119: v1(72.56,103.22) 71.92,103.22 71.83,103.3 71.83,103.67 71.91,103.75 74.02,103.75 74.85,104.59 89.46,104.59 92.29,101.75 104.18,101.75 108.34,97.59
  BOTTOM w0.076: v1(119.37,99.13) 118.94,98.7 118.94,93.7 119.29,93.35 119.29,93.05 119.1,92.86 119.1,92.47 119.13,92.42 119.23,92.23 119.23,91.23 119.29,91.17 119.4,90.95 UC1.D28
  BOTTOM w0.112: JDIMM1.28 70.95,103.24 72.54,103.24 v1(72.56,103.22)
DDR_A_D3: length 65.6
  IN1 w0.089: 108.57,95.99 113.05,95.99 114.05,94.99 118.79,94.99 119.61,95.82 119.61,96.45 v1(120.03,96.86)
  IN1 w0.119: 108.57,95.99 103.78,100.78 89.08,100.78 88.75,101.12 88.75,101.29 89.35,101.89 89.35,102.06 89.18,102.23 89.01,102.23 88.41,101.63 88.24,101.63 88.07,101.8 88.07,101.96 88.67,102.56 88.67,102.73 88.5,102.9 88.34,102.9 87.73,102.3 87.57,102.3 87.4,102.47 87.4,102.64 88,103.24 88,103.41 87.83,103.58 87.66,103.58 87.06,102.98 86.89,102.98 86.29,103.58 85.49,103.58 85.37,103.46 85.37,103.3 85.25,103.18 85.01,103.18 84.89,103.3 84.89,103.46 84.77,103.58 84.54,103.58 84.42,103.46 84.42,103.3 84.3,103.18 84.06,103.18 83.94,103.3 83.94,103.46 83.82,103.58 83.58,103.58 83.46,103.46 83.46,103.3 83.34,103.18 83.1,103.18 82.98,103.3 82.98,103.46 82.86,103.58 82.62,103.58 82.51,103.46 82.51,103.3 82.39,103.18 82.15,103.18 82.03,103.3 82.03,103.46 81.91,103.58 81.67,103.58 81.55,103.46 81.55,103.3 81.43,103.18 81.19,103.18 81.07,103.3 81.07,103.46 80.95,103.58 79.27,103.58 79.15,103.46 79.15,103.3 79.03,103.18 78.79,103.18 78.67,103.3 78.67,103.46 78.55,103.58 78.31,103.58 78.2,103.46 78.2,103.3 78.08,103.18 77.84,103.18 77.72,103.3 77.72,103.46 77.6,103.58 77.21,103.58 77.13,103.5 v1(77.13,103.22)
  BOTTOM w0.076: v1(120.03,96.86) 119.64,96.48 119.64,94.17 119.64,93.71 119.79,93.55 119.79,92.53 119.78,92.5 119.78,92.49 119.75,92.42 119.75,92.18 119.79,92.06 119.79,91.88 119.72,91.69 119.72,91.67 119.63,91.43 UC1.C28
  BOTTOM w0.112: v1(77.13,103.22) 77.13,103.34 77.78,103.99 JDIMM1.25
DDR_A_D4: length 63.5
  IN1 w0.119: v1(74.27,100.72) 74.91,100.08 85.38,100.08 86.74,98.72 103.13,98.72 107.28,94.57 112.22,94.57 114.29,92.5 119.66,92.5 121.76,94.61 121.76,96.38 v1(121.28,96.86)
  BOTTOM w0.076: v1(121.28,96.86) 120.9,96.48 120.9,94.45 121.05,94.29 121.05,93.57 120.91,93.42 120.91,92.98 121.1,92.79 121.1,92.51 121.09,92.5 121.05,92.43 120.94,92.23 UC1.B26
  BOTTOM w0.112: v1(74.27,100.72) 74.27,100.31 73.7,99.74 JDIMM1.42
DDR_A_D5: length 64.7
  IN1 w0.119: v1(121.28,95.59) 121.28,94.5 119.5,92.71 115.32,92.71 114.49,93.54 113.69,93.54 112.43,94.8 107.51,94.8 103.27,99.04 86.87,99.04 84.84,101.07 84.67,101.07 84.55,100.95 84.55,100.52 84.43,100.4 84.14,100.4 84.02,100.52 84.02,101.35 83.9,101.47 83.59,101.47 83.47,101.35 83.47,100.52 83.35,100.4 83.11,100.4 82.99,100.52 82.99,101.01 82.87,101.13 82.64,101.13 82.52,101.01 82.52,100.52 82.4,100.4 82.16,100.4 82.04,100.52 82.04,101.47 81.92,101.59 81.68,101.59 81.56,101.47 81.56,100.52 81.44,100.4 81.2,100.4 81.08,100.52 81.08,101.01 80.96,101.13 79.6,101.13 79.48,101.01 79.48,100.52 79.36,100.4 79.12,100.4 79,100.52 79,101.01 78.88,101.13 78.64,101.13 78.52,101.01 78.52,100.52 78.4,100.4 78.16,100.4 78.04,100.52 78.04,101.01 77.92,101.13 77.44,101.13 77.32,101.01 v1(77.32,100.73)
  BOTTOM w0.076: v1(121.28,95.59) 121.23,95.54 121.23,93.51 121.07,93.35 121.07,93.05 121.26,92.86 121.26,92.47 121.24,92.42 121.15,92.26 121.15,91.9 UC1.C26
  BOTTOM w0.112: JDIMM1.37 77.58,100.99 v1(77.32,100.73)
DDR_A_D6: length 65.3
  IN1 w0.089: 111.63,96.4 113.28,96.4 114.31,95.37 118.56,95.37 119.13,95.94 119.13,97.24 v1(120.03,98.13)
  IN1 w0.119: 111.63,96.4 109.08,96.4 104.05,101.43 92.16,101.43 91.89,101.7 91.72,101.7 91.46,101.43 91.29,101.43 91.12,101.6 91.12,101.77 91.39,102.03 91.39,102.2 91.22,102.37 91.05,102.37 90.54,101.87 90.37,101.87 90.21,102.04 90.21,102.2 90.71,102.71 90.71,102.88 89.34,104.25 75.12,104.25 v1(74.08,103.22)
  BOTTOM w0.076: UC1.B28 119.4,92.26 119.27,92.5 119.27,92.51 119.27,92.79 119.46,92.98 119.46,93.42 119.28,93.59 119.28,97.39 v1(120.03,98.13)
  BOTTOM w0.112: JDIMM1.24 70.95,104.24 73.88,104.24 74.08,104.04 v1(74.08,103.22)
DDR_A_D7: length 64.8
  IN1 w0.089: v1(120.03,97.5) 119.36,96.83 119.36,95.91 118.62,95.18 114.22,95.18 113.21,96.19 109.5,96.19
  IN1 w0.119: 109.5,96.19 108.83,96.19 103.91,101.11 90.76,101.11 90.31,101.55 90.14,101.55 89.7,101.11 89.53,101.11 89.36,101.28 89.36,101.44 89.81,101.89 89.81,102.06 89.72,102.14 89.72,102.31 90.19,102.78 90.19,102.95 90.02,103.12 89.85,103.12 89.38,102.65 89.21,102.65 89.04,102.82 89.04,102.99 89.51,103.45 89.51,103.62 89.34,103.79 89.17,103.79 88.71,103.33 88.54,103.33 87.93,103.93 76.63,103.93 76.51,103.81 76.51,103.75 76.37,103.61 76.15,103.61 76.03,103.72 76.03,103.81 75.91,103.93 75.3,103.93 75.17,103.8 75.17,103.43 75.38,103.22 v1(75.61,103.22)
  BOTTOM w0.076: UC1.A28 119.62,92.9 119.62,93.49 119.46,93.65 119.46,96.93 v1(120.03,97.5)
  BOTTOM w0.112: JDIMM1.29 77.8,102.99 77.6,102.78 76.16,102.78 75.73,103.22 v1(75.61,103.22)
DDR_A_D8: length 63.8
  IN1 w0.089: 119.09,100.77 119.09,99.62 118.58,99.1 118.24,99.1 117.76,98.63 117.76,98.1 v1(118.39,97.47)
  IN1 w0.119: v1(74.47,109.17) 74.86,109.56 75.73,109.56 75.75,109.58 89.3,109.58 93.51,105.38 115.97,105.38 119.09,102.26 119.09,100.77
  BOTTOM w0.076: v1(118.39,97.47) 117.98,97.07 117.98,94.97 118.58,94.37 118.58,93.61 118.39,93.42 118.39,92.98 118.58,92.79 118.58,92.51 118.46,92.29 UC1.B30
  BOTTOM w0.112: v1(74.47,109.17) 74.18,109.46 74.15,109.46 73.84,109.77 72.54,109.77 72.01,109.24 JDIMM1.4
DDR_A_D9: length 64.7
  IN1 w0.089: v1(116.96,95.99) 116.81,95.84 114.69,95.84 113.6,96.93 109.74,96.93 109.08,97.59
  IN1 w0.119: v1(74.35,105.93) 73.93,105.51 71.84,105.51 71.73,105.39 71.73,104.4 71.84,104.28 72.65,104.28 72.77,104.4 72.77,104.91 72.89,105.02 73.12,105.02 73.24,104.91 73.24,104.4 73.36,104.28 73.8,104.28 74.63,105.11 89.68,105.11 92.39,102.4 104.27,102.4 109.08,97.59
  BOTTOM w0.076: UC1.D30 117.57,90.67 117.37,90.86 117.37,90.88 117.37,91.67 117.44,91.85 117.44,92.09 117.4,92.21 117.4,92.4 117.46,92.53 117.46,93.43 116.96,93.92 v1(116.96,95.99)
  BOTTOM w0.112: v1(74.35,105.93) 74.24,106.03 74.19,106.03 73.76,106.47 72.32,106.47 72.09,106.24 70.95,106.24 JDIMM1.16
DDR_A_D10: length 64.3
  IN1 w0.119: v1(76,109.17) 76.44,108.72 77.46,108.72 77.73,108.45 89.52,108.45 93.24,104.74 106.49,104.74 106.61,104.62 106.61,103.54 106.73,103.42 106.97,103.42 107.09,103.54 107.09,104.52 107.21,104.64 107.45,104.64 107.57,104.52 107.57,103.54 107.69,103.42 109.7,103.42 109.82,103.54 109.82,104.62 109.94,104.74 115.58,104.74 v1(118.27,102.04)
  BOTTOM w0.076: UC1.B33 116.15,92.49 116.15,94 115.6,94.55 115.6,97.24 117.4,99.04 117.4,100.39 117.4,100.92
  BOTTOM w0.112: JDIMM1.3 78.09,109.49 77.94,109.64 76.5,109.64 76.31,109.46 76.29,109.46 v1(76,109.17) ; v1(118.27,102.04) 118.21,102.04 117.4,101.24 117.4,101.01 117.4,100.92
DDR_A_D11: length 63
  IN1 w0.089: v1(116.49,97.47) 111.78,97.47 111.17,98.08
  IN1 w0.119: 111.17,98.08 107.74,101.5 107.12,101.5 106.89,101.74 106.31,101.74 104.67,103.37 92.8,103.37 89.17,107 77.28,107 76.98,106.71 73.94,106.71 73.82,106.83 73.82,107.57 73.7,107.69 71.65,107.69 71.54,107.57 71.54,106.86 71.65,106.74 73.12,106.74 73.25,106.61 73.25,106.12 73.05,105.93 v1(72.83,105.93)
  BOTTOM w0.076: v1(116.49,97.47) 116.48,97.47 115.92,96.91 115.92,94.48 116.35,94.05 116.35,92.96 116.47,92.71 116.55,92.52 116.63,92.36 116.7,92.22 116.7,91.33 116.85,91 116.85,90.83 UC1.D32
  BOTTOM w0.112: JDIMM1.20 72.03,105.24 72.72,105.93 v1(72.83,105.93)
DDR_A_D12: length 63.1
  IN1 w0.089: 119.41,100.77 119.41,99.69 118.78,99.05 118.78,98.5 v1(118.39,98.11)
  IN1 w0.119: v1(72.95,109.17) 73.68,109.9 75.62,109.9 75.62,109.91 89.44,109.91 93.64,105.7 116.11,105.7 119.41,102.4 119.41,100.77
  BOTTOM w0.076: v1(118.39,98.11) 117.82,97.54 117.82,94.83 118.42,94.23 118.42,93.68 118.22,93.49 118.22,92.9 UC1.A30
  BOTTOM w0.112: JDIMM1.8 70.95,108.24 72.05,108.24 72.66,108.85 72.66,108.88 v1(72.95,109.17)
DDR_A_D13: length 63.3
  IN1 w0.089: v1(118.39,96.2) 117.52,97.07 117.52,98.64 118.17,99.28 118.51,99.28 118.77,99.55 118.77,100.77
  IN1 w0.119: 118.77,100.77 118.77,102.13 115.84,105.06 109.61,105.06 109.5,104.94 109.5,103.86 109.38,103.74 108.01,103.74 107.89,103.86 107.89,104.94 107.77,105.06 93.37,105.06 89.65,108.78 82.48,108.78 82.36,108.9 82.36,109.03 82.24,109.15 82,109.15 81.88,109.03 81.88,108.9 81.76,108.78 81.52,108.78 81.4,108.9 81.4,109.14 81.29,109.26 81.05,109.26 80.93,109.14 80.93,108.9 80.81,108.78 79.93,108.78 79.81,108.9 79.81,109.14 79.69,109.26 79.45,109.26 79.33,109.14 79.33,108.9 79.22,108.78 78.98,108.78 78.86,108.9 78.86,109.14 78.74,109.26 78.5,109.26 78.38,109.14 78.38,108.9 78.26,108.78 77.91,108.78 v1(77.52,109.17)
  BOTTOM w0.076: v1(118.39,96.2) 118.75,95.84 118.75,93.54 118.55,93.35 118.55,93.05 118.74,92.86 118.74,92.47 118.6,92.21 118.59,92.19 118.59,91.6 UC1.C30
  BOTTOM w0.112: v1(77.52,109.17) 77.81,108.88 77.81,108.85 78.17,108.49 79.15,108.49 JDIMM1.7
DDR_A_D14: length 62.2
  IN1 w0.089: 111.21,97.58 111.5,97.29 114,97.29 114.45,96.84 v1(116.37,96.84)
  IN1 w0.119: 111.21,97.58 110.93,97.86 110.76,97.86 110.31,97.41 110.14,97.41 109.97,97.57 109.97,97.74 110.43,98.2 110.43,98.36 109.64,99.15 109.47,99.15 109.04,98.72 108.87,98.72 108.7,98.89 108.7,99.06 109.13,99.49 109.13,99.66 108.96,99.83 108.79,99.83 108.36,99.4 108.19,99.4 108.02,99.57 108.02,99.74 108.45,100.17 108.45,100.34 108.28,100.51 108.12,100.51 107.68,100.07 107.52,100.07 107.35,100.24 107.35,100.41 107.78,100.84 107.78,101.01 107.61,101.18 107.44,101.18 107.01,100.75 106.84,100.75 106.69,100.9 106.69,101.07 106.72,101.1 106.72,101.27 106.58,101.41 106.41,101.41 106.38,101.38 106.21,101.38 104.54,103.05 92.67,103.05 89.35,106.37 88.54,106.37 88.31,106.6 88.06,106.6 87.83,106.37 87.59,106.37 87.36,106.6 87.11,106.6 86.88,106.37 86.63,106.37 86.4,106.6 86.15,106.6 85.92,106.37 85.68,106.37 85.45,106.6 85.2,106.6 84.97,106.37 84.72,106.37 84.49,106.6 84.24,106.6 84.01,106.37 83.77,106.37 83.54,106.6 83.29,106.6 83.06,106.37 82.81,106.37 82.58,106.6 82.33,106.6 82.1,106.37 81.86,106.37 81.63,106.6 81.38,106.6 81.15,106.37 80.9,106.37 80.67,106.6 80.42,106.6 80.19,106.37 79.95,106.37 79.72,106.6 79.47,106.6 79.24,106.37 78.99,106.37 78.76,106.6 78.51,106.6 78.28,106.37 78.04,106.37 77.81,106.6 77.56,106.6 77.33,106.37 76.32,106.37 v1(75.87,105.93)
  BOTTOM w0.076: v1(116.37,96.84) 116.11,96.58 116.11,94.52 116.54,94.1 116.54,92.98 116.71,92.6 116.71,92.57 116.77,92.45 116.77,92.44 116.79,92.43 116.79,92.43 116.95,92.07 UC1.B32
  BOTTOM w0.112: v1(75.87,105.93) 75.87,105.88 76.76,104.99 79.15,104.99 JDIMM1.21
DDR_A_D15: length 62.1
  IN1 w0.089: v1(116.49,96.29) 114.75,96.29 113.93,97.11 110.02,97.11 109.54,97.59
  IN1 w0.119: 109.54,97.59 109.54,97.76 109.93,98.15 109.93,98.32 109.76,98.49 109.59,98.49 109.2,98.1 109.03,98.1 104.4,102.73 92.52,102.73 89.8,105.45 89.18,105.45 89.06,105.57 89.06,105.93 88.94,106.05 88.7,106.05 88.58,105.93 88.58,105.57 88.46,105.45 88.23,105.45 88.11,105.57 88.11,105.93 87.99,106.05 87.75,106.05 87.63,105.93 87.63,105.57 87.51,105.45 87.27,105.45 87.15,105.57 87.15,105.93 87.03,106.05 86.79,106.05 86.67,105.93 86.67,105.57 86.55,105.45 86.32,105.45 86.2,105.57 86.2,105.93 86.08,106.05 85.84,106.05 85.72,105.93 85.72,105.57 85.6,105.45 85.36,105.45 85.24,105.57 85.24,105.93 85.12,106.05 84.88,106.05 84.76,105.93 84.76,105.57 84.64,105.45 84.41,105.45 84.29,105.57 84.29,105.93 84.17,106.05 83.93,106.05 83.81,105.93 83.81,105.57 83.69,105.45 83.44,105.45 83.32,105.57 83.32,105.92 83.2,106.04 82.96,106.04 82.84,105.92 82.84,105.57 82.73,105.45 82.49,105.45 82.37,105.57 82.37,105.92 82.25,106.04 82.01,106.04 81.89,105.92 81.89,105.57 81.77,105.45 81.53,105.45 81.41,105.57 81.41,105.92 81.29,106.04 81.05,106.04 80.93,105.92 80.93,105.57 80.81,105.45 79.6,105.45 79.48,105.57 79.48,105.93 79.36,106.05 79.12,106.05 79,105.93 79,105.57 78.88,105.45 78.64,105.45 78.52,105.57 78.52,105.93 78.4,106.05 78.16,106.05 78.04,105.93 78.04,105.57 77.92,105.45 77.33,105.45 77.25,105.53 77.25,105.78 v1(77.4,105.93)
  BOTTOM w0.076: v1(116.49,96.29) 116.49,94.37 116.7,94.16 116.7,93.9 117.29,93.31 117.29,92.56 117.23,92.43 117.23,92.18 117.28,92.06 117.28,91.88 117.21,91.7 117.21,91.69 117.18,91.6 117.18,91.48 UC1.C32
  BOTTOM w0.112: v1(77.4,105.93) 77.46,105.99 JDIMM1.17
DDR_A_D16: length 50.1
  IN1 w0.119: v1(75.85,98.15) 76.26,98.56 77.88,98.56 77.99,98.44 77.99,98.05 78.11,97.93 78.38,97.93 78.5,98.05 78.5,98.41 78.65,98.56 81.07,98.56 81.19,98.44 81.19,98.02 81.31,97.9 81.55,97.9 81.67,98.02 81.67,98.44 81.79,98.56 82.03,98.56 82.15,98.44 82.15,98.28 82.27,98.16 82.51,98.16 82.63,98.28 82.63,98.44 82.74,98.56 82.95,98.56 83.34,98.17 84.88,98.17 85.85,97.2 102.9,97.2 106.5,93.6 109.95,93.6 110.02,93.53 v1(110.02,93.22)
  BOTTOM w0.076: 110.55,92.69 110.67,92.57 111.19,92.57 111.76,91.99 111.76,90.84 112.64,89.96 112.64,89.02 112.64,88.89 113.04,88.49 113.83,88.49 UC1.H37
  BOTTOM w0.112: v1(75.85,98.15) 76.69,98.99 JDIMM1.45 ; 110.55,92.69 v1(110.02,93.22)
DDR_A_D17: length 51.9
  IN1 w0.119: v1(72.8,98.15) 73.86,99.21 84.76,99.21 86.1,97.87 103.06,97.87 106.92,94.01 110.85,94.01 111.46,93.56 111.92,93.23 v1(111.92,93.22)
  BOTTOM w0.076: UC1.H34 115.59,88.86 114.35,88.86 114.07,89.01 113.69,89.01 113.5,88.82 113.18,88.82 112.97,89.02 112.97,90.1 112.09,90.98 112.09,93.05 v1(111.92,93.22)
  BOTTOM w0.112: v1(72.8,98.15) 72.21,98.74 JDIMM1.46
DDR_A_D18: length 52.8
  IN1 w0.089: v1(111.05,91.91) 110.6,91.47 106.9,91.47 102.77,95.6 102.14,95.6
  IN1 w0.119: 102.14,95.6 81.57,95.6 80.87,96.31 74.32,96.31 74.2,96.43 74.2,96.84 73.93,97.11 73.02,97.11 72.75,96.84 v1(72.75,95.48)
  BOTTOM w0.076: v1(111.05,91.91) 111.43,91.53 111.43,90.69 112.3,89.82 112.3,88.76 112.62,88.44 112.84,88.22 112.91,88.15 114.04,88.15 114.15,88.19 114.33,88.19 114.45,88.15 114.69,88.15 114.88,88.22 115.69,88.22 115.87,88.04 UC1.K34
  BOTTOM w0.112: JDIMM1.58 72.07,95.74 72.33,95.48 v1(72.75,95.48)
DDR_A_D19: length 52.4
  IN1 w0.089: v1(108.65,90.61) 106.74,90.61 102.71,94.64 102.14,94.64
  IN1 w0.119: v1(75.79,95.48) 75.37,95.05 75.15,95.05 75.03,94.94 75.03,94.22 75.15,94.1 75.39,94.1 75.51,94.22 75.51,94.36 75.63,94.48 75.87,94.48 75.99,94.36 75.99,93.97 76.11,93.85 76.35,93.85 76.47,93.97 76.47,94.36 76.58,94.48 76.82,94.48 76.94,94.36 76.94,93.97 77.06,93.85 85.68,93.85 86.47,94.64 102.14,94.64
  BOTTOM w0.076: UC1.K35 114.9,86.96 114.28,86.96 114.17,86.9 114.05,86.83 113.71,86.83 113.5,87.04 113.19,87.04 113.01,86.86 112.17,86.86 111.47,87.56 111.47,89.45 111.14,89.78 109.47,89.78 v1(108.65,90.61)
  BOTTOM w0.112: v1(75.79,95.48) 76.78,94.49 79.15,94.49 JDIMM1.63
DDR_A_D20: length 50.9
  IN1 w0.119: v1(110.65,93.22) 110.65,93.56 110.4,93.8 106.72,93.8 102.99,97.53 85.97,97.53 84.62,98.88 74.22,98.88 74.02,98.68 74.02,98.45 v1(74.32,98.15)
  BOTTOM w0.076: UC1.H36 114.51,88.58 114.03,88.84 113.76,88.84 113.57,88.65 113.11,88.65 112.81,88.95 112.81,90.03 111.93,90.91 111.93,92.08 111.18,92.83 111.04,92.83 110.87,93
  BOTTOM w0.112: 110.87,93 v1(110.65,93.22) ; JDIMM1.50 72.23,97.74 72.39,97.58 73.76,97.58 v1(74.32,98.15)
DDR_A_D21: length 51.7
  IN1 w0.119: v1(108.75,93.22) 106.44,93.22 102.79,96.87 85.07,96.87 84.86,97.08 84.86,97.73 84.75,97.85 84.51,97.85 84.39,97.73 84.39,97.08 84.27,96.96 84.03,96.96 83.91,97.08 83.91,97.73 83.79,97.85 83.55,97.85 83.43,97.73 83.43,97.08 83.31,96.96 83.07,96.96 82.95,97.08 82.95,97.73 82.84,97.85 82.6,97.85 82.48,97.73 82.48,97.08 82.36,96.96 82.02,96.96 81.4,97.58 80.38,97.58 80.26,97.7 80.26,98.12 80.14,98.24 79.9,98.24 79.78,98.12 79.78,97.7 79.66,97.58 79.42,97.58 79.3,97.7 79.3,98.12 79.18,98.24 78.94,98.24 78.83,98.12 78.83,97.7 78.71,97.58 78.01,97.58 77.44,98.15 v1(77.37,98.15)
  BOTTOM w0.076: 109.47,92.49 109.56,92.4 111.11,92.4 111.44,92.08 111.44,92.07 111.6,91.91 111.6,90.76 112.47,89.89 112.47,88.82 112.68,88.61 112.98,88.31 114.01,88.31 114.12,88.36 114.36,88.36 114.48,88.31 114.66,88.31 114.85,88.39 114.86,88.39 115.12,88.48 UC1.H35
  BOTTOM w0.112: v1(77.37,98.15) 77.79,98.15 77.95,97.99 79.15,97.99 JDIMM1.49 ; 109.47,92.49 v1(108.75,93.22)
DDR_A_D22: length 51.6
  IN1 w0.089: 102.14,94.96 102.72,94.96 106.69,90.99 109.53,90.99 v1(109.92,90.61)
  IN1 w0.119: 102.14,94.96 86.34,94.96 85.56,94.18 80.56,94.18 80.44,94.3 80.44,94.75 80.32,94.86 80.08,94.86 79.96,94.75 79.96,94.3 79.84,94.18 79.54,94.18 79.42,94.3 79.42,95.45 79.3,95.56 78.99,95.56 78.87,95.45 78.87,94.3 78.75,94.18 78.51,94.18 78.39,94.3 78.39,95.45 78.27,95.56 78.03,95.56 77.92,95.45 77.92,94.3 77.8,94.18 77.56,94.18 77.44,94.3 77.44,94.55 77.32,94.67 77.12,94.67 77,94.79 77,95.16 v1(77.32,95.48)
  BOTTOM w0.076: UC1.K36 114.51,87.28 114.03,87.01 113.76,87.01 113.57,87.2 113.12,87.2 112.94,87.03 112.24,87.03 111.63,87.63 111.63,89.52 111.07,90.08 110.44,90.08 v1(109.92,90.61)
  BOTTOM w0.112: v1(77.32,95.48) 77.33,95.49 JDIMM1.59
DDR_A_D23: length 50.8
  IN1 w0.089: 102.14,95.28 102.73,95.28 106.75,91.26 109.9,91.26 v1(110.55,90.61)
  IN1 w0.119: v1(74.27,95.48) 74.77,95.97 80.75,95.97 80.96,95.76 80.96,94.62 81.08,94.5 84.1,94.5 84.22,94.62 84.22,94.94 84.34,95.05 84.58,95.05 84.7,94.94 84.7,94.62 84.82,94.5 85.05,94.5 85.17,94.62 85.17,95.16 85.29,95.28 102.14,95.28
  BOTTOM w0.076: v1(110.55,90.61) 110.78,90.61 111.8,89.59 111.8,87.7 112.31,87.19 112.88,87.19 113.05,87.37 113.83,87.37 UC1.K37
  BOTTOM w0.112: v1(74.27,95.48) 73.53,94.74 JDIMM1.62
DDR_A_D24: length 51.7
  IN1 w0.089: v1(109.83,89.3) 109.19,89.94 106.43,89.94 102.59,93.79 102.14,93.79
  IN1 w0.119: 102.14,93.79 86.82,93.79 86.02,92.98 85.49,92.98 85.37,92.87 85.37,92.7 85.25,92.58 85.01,92.58 84.89,92.7 84.89,92.87 84.77,92.98 84.53,92.98 84.41,92.87 84.41,92.45 84.29,92.33 84.05,92.33 83.93,92.45 83.93,92.87 83.81,92.98 83.58,92.98 83.46,92.87 83.46,92.45 83.34,92.33 83.1,92.33 82.98,92.45 82.98,92.87 82.86,92.98 82.62,92.98 82.5,92.87 82.5,92.45 82.38,92.33 82.14,92.33 82.02,92.45 82.02,92.87 81.9,92.98 81.67,92.98 81.55,92.87 81.55,92.53 81.43,92.41 81.19,92.41 81.07,92.53 81.07,92.87 80.95,92.98 75.91,92.98 75.79,92.87 v1(75.79,92.57)
  BOTTOM w0.076: v1(109.83,89.3) 110.28,88.85 110.66,88.85 111.11,88.39 111.11,87.44 111.11,87.3 112.07,86.35 112.9,86.35 113.12,86.13 113.57,86.13 113.74,86.3 113.75,86.3 113.77,86.31 114.05,86.31 114.14,86.26 114.51,86.06 UC1.N36
  BOTTOM w0.112: JDIMM1.67 76.71,93.49 v1(75.79,92.57)
DDR_A_D25: length 51.3
  IN1 w0.089: 102.14,94.11 102.63,94.11 106.62,90.12 110.25,90.12 v1(111.07,89.29)
  IN1 w0.119: v1(72.74,92.57) 72.74,93.02 72.86,93.14 73.35,93.14 73.47,93.02 73.71,93.02 73.83,93.14 73.83,93.67 73.95,93.78 74.19,93.78 74.31,93.67 74.31,93.44 74.43,93.32 85.9,93.32 86.69,94.11 102.14,94.11
  BOTTOM w0.076: UC1.N34 115.64,86.06 115.33,86.38 115.11,86.38 115.11,86.38 114.87,86.38 114.86,86.38 114.28,86.38 114.09,86.48 113.7,86.48 113.69,86.47 113.67,86.47 113.5,86.3 113.18,86.3 112.97,86.51 112.14,86.51 111.28,87.37 111.28,88.46 111.1,88.64 111.1,89.27 v1(111.07,89.29)
  BOTTOM w0.112: JDIMM1.70 72.16,92.74 72.33,92.57 v1(72.74,92.57)
DDR_A_D26: length 51
  IN1 w0.089: 102.14,91.55 102.34,91.55 106.5,87.39 109.74,87.39 110.02,87.11 v1(110.02,86.69)
  IN1 w0.119: 102.14,91.55 87.75,91.55 84.65,88.45 83.8,88.45 83.68,88.57 83.68,89.03 83.56,89.15 83.32,89.15 83.2,89.03 83.2,88.57 83.08,88.45 82.84,88.45 82.72,88.57 82.72,89.57 82.6,89.69 82.36,89.69 82.24,89.57 82.24,88.57 82.12,88.45 81.89,88.45 81.77,88.57 81.77,89.57 81.65,89.69 76.21,89.69 v1(75.79,89.27)
  BOTTOM w0.076: v1(110.02,86.69) 110.3,86.69 112.29,84.7 112.9,84.7 113.06,84.86 113.82,84.86 UC1.R37
  BOTTOM w0.112: JDIMM1.79 77.01,90.49 v1(75.79,89.27)
DDR_A_D27: length 51.4
  IN1 w0.089: 102.14,91.87 102.28,91.87 106.58,87.57 109.95,87.57 v1(110.37,87.99)
  IN1 w0.119: v1(72.75,89.27) 73.26,89.78 75.65,89.78 75.87,90.01 83.07,90.01 83.19,89.89 83.19,89.59 83.31,89.47 83.55,89.47 83.67,89.59 83.67,89.89 83.79,90.01 85.75,90.01 87.62,91.87 102.14,91.87
  BOTTOM w0.076: UC1.R34 115.87,85.49 115.83,85.53 115.83,85.53 115.65,85.71 114.91,85.71 114.69,85.63 114.45,85.63 114.33,85.67 114.15,85.67 114.02,85.63 112.93,85.63 112.92,85.63 112.91,85.63 112.75,85.79 111.93,85.79 110.58,87.13 110.58,87.79 v1(110.37,87.99)
  BOTTOM w0.112: v1(72.75,89.27) 72.75,88.99 72.63,88.87 72.32,88.87 71.95,89.24 JDIMM1.84
DDR_A_D28: length 51
  IN1 w0.089: 102.14,93.47 102.43,93.47 106.19,89.7 109.04,89.7 109.19,89.55 v1(109.19,89.3)
  IN1 w0.119: 102.14,93.47 86.96,93.47 85.58,92.09 84.51,92.09 84.39,91.97 84.39,91.87 84.27,91.75 84.03,91.75 83.91,91.87 83.91,91.97 83.79,92.09 83.55,92.09 83.43,91.97 83.43,91.72 83.31,91.6 83.07,91.6 82.96,91.72 82.96,91.97 82.84,92.09 82.6,92.09 82.48,91.97 82.48,91.72 82.36,91.6 82.12,91.6 82,91.72 82,91.97 81.88,92.09 80.02,92.09 79.75,91.82 79.54,91.82 79.41,91.94 79.41,92.52 79.29,92.64 79.03,92.64 78.9,92.51 78.9,91.69 78.81,91.6 78.44,91.6 78.32,91.72 78.32,92.54 78.2,92.66 77.96,92.66 77.84,92.54 77.84,91.72 77.72,91.6 76.45,91.6 76.3,91.75 76.3,92.01 76.42,92.13 77.15,92.13 77.32,92.3 v1(77.32,92.57)
  BOTTOM w0.076: UC1.N37 113.82,85.96 113.05,85.96 112.83,86.18 112,86.18 110.92,87.26 110.92,88.35 110.59,88.68 109.81,88.68 v1(109.19,89.3)
  BOTTOM w0.112: v1(77.32,92.57) 77.73,92.57 77.81,92.49 79.15,92.49 JDIMM1.71
DDR_A_D29: length 51.2
  IN1 w0.089: 102.14,93.14 102.33,93.14 106.17,89.3 v1(107.92,89.3)
  IN1 w0.119: v1(74.27,92.57) 74.08,92.37 74.08,91.88 74.19,91.76 75.88,91.76 76,91.64 76,91.4 76.12,91.28 79.92,91.28 80.04,91.4 80.04,91.64 80.16,91.76 81.15,91.76 81.64,91.28 85.22,91.28 87.09,93.14 102.14,93.14
  BOTTOM w0.076: UC1.N35 115.06,85.9 114.94,85.9 114.8,85.85 114.66,85.8 114.48,85.8 114.33,85.85 114.16,85.85 114.01,85.8 112.98,85.8 112.76,86.02 111.93,86.02 110.75,87.2 110.75,87.33 110.75,88.28 110.52,88.52 108.71,88.52 v1(107.92,89.3)
  BOTTOM w0.112: JDIMM1.66 73.1,93.74 v1(74.27,92.57)
DDR_A_D30: length 52.1
  IN1 w0.089: 102.14,91.23 102.29,91.23 106.32,87.19 109.31,87.19 109.39,87.11 v1(109.39,86.69)
  IN1 w0.119: v1(77.32,89.27) 77.32,88.26 77.5,88.08 77.91,88.08 78.03,88.19 78.03,89.24 78.15,89.36 78.38,89.36 78.5,89.24 78.5,88.19 78.62,88.08 78.86,88.08 78.98,88.19 78.98,89.24 79.1,89.36 79.34,89.36 79.46,89.24 79.46,88.19 79.58,88.08 79.84,88.08 79.96,88.19 79.96,88.76 80.08,88.88 80.31,88.88 80.43,88.76 80.43,88.19 80.55,88.08 80.85,88.08 80.97,88.19 80.97,88.78 81.09,88.9 81.32,88.9 81.44,88.78 81.44,88.19 81.56,88.08 84.73,88.08 87.88,91.23 102.14,91.23
  BOTTOM w0.076: v1(109.39,86.69) 109.76,86.32 110.43,86.32 112.22,84.54 112.97,84.54 113.12,84.69 113.56,84.69 113.75,84.5 114.05,84.5 114.24,84.61 UC1.R36
  BOTTOM w0.112: v1(77.32,89.27) 77.8,89.27 78.02,89.49 JDIMM1.83
DDR_A_D31: length 51.4
  IN1 w0.089: 102.14,90.91 102.23,90.91 106.44,86.69 v1(108.12,86.69)
  IN1 w0.119: 102.14,90.91 88.02,90.91 84.86,87.75 76.81,87.75 76.7,87.87 76.7,88.71 76.58,88.83 76.34,88.83 76.22,88.71 76.22,87.87 76.1,87.75 75.79,87.75 v1(74.27,89.27)
  BOTTOM w0.076: v1(108.12,86.69) 108.67,86.14 110.38,86.14 112.15,84.37 113.04,84.37 113.19,84.53 113.5,84.53 113.68,84.34 114.09,84.34 114.27,84.44 114.67,84.44 UC1.R35
  BOTTOM w0.112: v1(74.27,89.27) 73.69,89.85 72.68,89.85 72.29,90.24 JDIMM1.80
DDR_A_D32: length 53.1
  IN1 w0.119: v1(111.8,74.14) 111.8,73.85 111.51,73.56 104.01,73.56 103.44,72.98 96.77,72.98 93.78,70 93.47,70 93.35,70.12 93.35,71.37 93.23,71.49 92.99,71.49 92.87,71.37 92.87,70.12 92.75,70 92.51,70 92.39,70.12 92.39,70.55 92.28,70.67 92.04,70.67 91.92,70.55 91.92,70.12 91.8,70 91.12,70 85.63,64.5 74.66,64.5 v1(74.22,64.95)
  BOTTOM w0.076: v1(111.8,74.14) 112.02,73.92 112.98,73.92 113.19,73.71 113.51,73.71 113.7,73.9 114.07,73.9 114.27,73.79 114.9,73.79 UC1.AN35
  BOTTOM w0.112: JDIMM1.174 71.99,64.74 72.2,64.53 73.8,64.53 v1(74.22,64.95)
