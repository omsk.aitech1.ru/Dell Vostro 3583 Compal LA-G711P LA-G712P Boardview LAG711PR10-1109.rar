# Allegro board LAG711PR10-1109.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): 195.48,67.95 195.48,63.65 195.42,63.6 192.98,63.6 192.83,63.75 192.83,67.86 192.93,67.96 193.05,67.99 193.16,68.01 195.41,68.01
+5VS on IN2 (solid shape): outline of 185 points within 26.07,17.78 36.74,22.89
+5VS on IN2: 118.03,26.54 118.09,26.6 123.73,26.6 124.37,27.24 133.54,27.24 138.04,31.75 144.81,31.75 150.47,26.09 150.47,25.01 150.07,24.62 102.66,24.62 101.83,24.46 101.13,23.99 100.81,23.67 54.07,23.67 50.38,27.36 37.44,27.36 35.91,28.89 35.91,36.32 36.99,37.4 37.04,37.4 37.8,38.16 37.8,60.31 38.23,60.74 40.64,60.74 40.99,60.38 41.94,60.38 44.8,57.53 44.8,55.37 43.6,54.16 43.6,38.54 47.28,34.86 47.28,32.19 47.79,31.68 50.71,31.68 52.68,29.71 54.83,29.71 57.31,27.24 59.98,27.24 61.21,26.01 64.68,26.01 65.56,25.12 68.54,25.12 68.56,25.11 95.04,25.11 95.04,25.12 96.29,25.12 96.71,25.54 100.39,25.54 101.39,26.54 ; 1 cut-out
+5VS on IN2: 214.14,29.33 213.34,30.14 207.68,30.14 207.14,30.68 207.14,32.14 207.45,32.44 209.32,32.44 220.44,43.56 220.44,48.7 221.71,49.97 221.71,55.11 219.49,57.34 217.16,57.34 216.91,57.44 216.66,57.34 213.82,57.34 213.8,57.37 213.78,57.39 213.75,57.46 213.78,57.53 213.52,58.14 213.26,57.53 213.29,57.46 213.26,57.39 213.24,57.37 213.22,57.34 203.42,57.34 201.29,59.47 201.29,59.48 201.2,59.62 201.06,59.7 201.05,59.71 196.64,64.12 193.61,64.12 193.57,64.16 191.04,64.16 190,65.19 188.61,65.19 186.88,66.92 186.82,66.92 186.82,66.98 183.56,70.24 183.56,70.89 183.79,71.12 185.44,71.12 185.66,70.96 185.9,70.83 186.82,70.4 190.86,68.51 191.66,68.14 192.4,67.94 193.17,68.02 193.32,68.06 194.78,66.61 199.81,66.61 205.46,60.96 208.89,60.96 210.41,62.48 217.31,62.48 217.32,62.48 217.46,62.45 217.6,62.48 217.61,62.48 220.89,62.48 223.38,59.98 223.39,59.97 223.48,59.8 223.65,59.71 223.66,59.7 224.19,59.18 224.19,36.21 221.14,33.16 221.14,31.62 218.86,29.33
+5VS on IN3: 35.02,21.33 35.02,8.31 36.8,6.54 39.85,6.54 39.98,6.66 39.98,22.41 38.74,23.65 38.74,24.35 36.23,26.86 34.58,26.86 33.94,27.49 33.94,28.32 35.4,29.78 35.4,31.36 35.72,31.68 38.45,31.68 38.71,31.94 38.71,33.52 38.39,33.84 33.44,33.84 33.18,33.59 31.97,33.59 30.45,32.06 30.45,25.9
+17.4V_BATT+ on TOP (solid shape): 177.96,41.97 177.96,41.46 178.72,40.7 178.72,37.46 178.47,37.21 177.39,37.21 177.07,36.89 177.07,35.87 176.88,35.68 176.37,35.68 176.18,35.87 176.18,37.78 175.68,38.29 175.17,38.29 174.56,38.89 174.56,38.98 174.62,39.02 174.67,39.07 174.72,39.47 174.36,39.66 174.28,39.69 174.25,39.77 174.07,40.12 173.68,40.09 173.57,40.08 173.52,40.17 173.52,43.75 173.39,43.87 172.12,43.87 171.99,44 171.99,44.38 172.12,44.51 175.42,44.51
+17.4V_BATT+ on BOTTOM (solid shape): 175.74,46.6 175.74,45.97 175.93,45.78 176.56,45.78 176.69,45.65 176.69,45.14 175.55,45.14 175.55,44.38 176.69,44.38 176.69,42.86 178.22,41.33 179.49,41.33 179.61,41.21 179.61,39.81 179.51,39.7 175.4,39.7 173.64,41.46 173.64,43.62 173.39,43.87 172.12,43.87 171.99,44 171.99,46.16 172.12,46.29 173.52,46.29 173.71,46.1 174.34,46.1 174.91,46.67 175.68,46.67
+17.4V_BATT+ on IN3 (solid shape): 174.66,44.51 174.66,43.24 174.53,43.11 173.77,43.11 173.33,42.67 172.88,43.11 172.12,43.11 171.99,43.24 171.99,44.51 172.12,44.64 174.53,44.64
+17.4V_BATT++ on BOTTOM (solid shape): 174.21,39 174.41,38.95 174.6,39 179.61,39 179.74,38.88 179.74,37.4 179.36,37.02 179.36,36.38 179.1,36.13 175.42,36.13 174.53,35.24 173.64,35.24 172.63,36.25 172.63,37.9 173.72,39
+17.4V_BATT++ on BOTTOM (solid shape): outline of 106 points within 151.67,32.95 159.51,41.05
+17.4V_BATT+_R on BOTTOM (solid shape): 182.91,49.21 182.91,42.92 183.68,42.16 183.68,40.32 183.23,39.87 180.56,39.87 180.37,40.06 180.37,41.21 177.71,43.87 177.71,44.38 178.62,44.38 178.62,45.14 177.71,45.14 177.71,45.65 177.83,45.78 178.22,45.78 178.41,45.97 178.41,46.6 178.47,46.67 178.72,46.67 178.98,46.92 178.98,47.55 180.18,48.76 180.18,49.27 180.31,49.4 182.72,49.4
+19V_ADPIN on TOP (solid shape): 87.54,143.7 87.54,140.27 87.03,139.76 83.09,139.76 82.71,140.14 82.71,143.57 83.47,144.33 86.9,144.33
+19V_ADPIN on BOTTOM (solid shape): 86.08,144.72 86.08,141.11 85.75,140.77 83.05,140.77 82.79,141.04 82.79,144.65 83.02,144.88 85.92,144.88
+19V_VIN on TOP (solid shape): 109.89,152.52 109.89,151.44 104.62,146.17 89.67,146.17 88.02,144.52 85.95,144.52 85.95,145.09 84.55,145.09 84.55,144.52 83.73,144.52 83.41,144.84 83.41,147.95 83.6,148.14 87.76,148.14 88.61,148.98 98.94,148.98 99.05,148.98 104.02,148.98 104.02,150.27 106.82,153.07 109.34,153.07
+19V_VIN on TOP (solid shape): 212.85,52.39 212.85,51.97 212.82,51.95 212.68,51.72 212.8,51.48 212.8,50.42 212.55,50.17 210.85,50.17 210.08,50.94 210.08,52.61 210.24,52.77 212.46,52.77
+19V_VIN on TOP (solid shape): outline of 1230 points within 159.61,55.88 189.26,119.06
+19V_VIN on BOTTOM (solid shape): 130.44,152.38 130.56,152.36 130.68,152.38 135.94,152.38 136.18,152.14 136.18,149.79 135.86,149.47 130.56,149.47 130.04,149.99 130.04,152.07 130.35,152.38
+19V_VIN on BOTTOM (solid shape): 168.22,121 169.16,121 169.33,120.83 169.33,117.29 169.23,117.18 168.98,117.05 168.85,116.81 168.28,116.23 168.28,114.6 168.2,114.51 167.65,114.51 167.26,114.51 166.87,114.47 163.44,114.47 163.23,114.68 163.23,116.64 163.86,117.28 165.41,117.28 166.57,118.43 166.57,120.9 166.68,121.01 168.21,121.01
+19V_VIN on BOTTOM (solid shape): 109.78,152.99 109.78,150.67 109.64,150.53 108.09,150.53 102.87,145.32 92.97,145.32 92.3,144.65 86.52,144.65 85.31,145.85 85.31,147.51 85.63,147.82 90.52,147.82 91.54,148.84 101.19,148.84 104.08,151.73 104.5,151.73 105.62,152.16 106.16,153.23 109.54,153.23
+19V_VIN on BOTTOM (solid shape): 171.48,91.44 173.5,83.49 178.28,76.83 178.64,76.49 179,76.17 179,75.87 178.88,75.75 178.72,75.75 176.77,75.75 176.36,76.15 176.36,76.36 175.52,77.2 174.49,78.55 174.49,78.94 174.4,79.07 173.44,80.39 172.49,81.71 172.46,81.74 172.33,81.87 172.31,81.91 171.01,84.24 170.28,86.8 170.28,86.86 170.18,86.96 170.08,87.18 169.86,87.28 169.76,87.38 169.76,87.44 169.6,87.59 169.6,88.62 169.26,88.96 169.26,92.07 169.26,92.07 169.26,92.89 168.88,93.27 168.88,94.8 168.44,95.25 168.44,100.48 168.46,100.5 168.44,100.78 168.44,100.98 168.44,102.8 168.89,103.25 170.73,103.25
+19VB on TOP (solid shape): 162.34,98.86 162.34,98.61 161.07,97.34 160.69,97.34 158.53,99.5 157.64,99.5 157.51,99.63 157.51,101.28 157.64,101.4 159.8,101.4
+19VB on TOP (solid shape): 175.29,76.39 175.29,76 174.79,75.5 174.02,75.5 173.01,74.48 171.23,74.48 170.21,75.5 170.21,75.92 171.69,77.4 172.25,77.4 173.14,78.29 173.39,78.29
+19VB on TOP (solid shape): 50.81,25.22 51.3,25.22 51.3,25.78 51.7,25.78 52.27,25.2 54.64,25.2 54.77,25.08 54.77,23.81 54.64,23.68 47.91,23.68 47.65,23.95 47.65,24.39 48.1,24.84 48.1,25.4 48.13,25.43 50.18,25.43 50.53,25.78 50.81,25.78
+19VB on TOP (solid shape): 166.34,49.33 166.34,47.45 166.14,47.25 166.03,47.25 165.86,47.28 165.69,47.25 165.47,47.25 164.85,47.87 164.31,47.87 164.18,48 164.18,48.38 164.75,48.38 164.75,48.89 164.18,48.89 164.18,49.4 164.31,49.53 166.15,49.53
+19VB on BOTTOM (solid shape): 166.29,49.33 166.29,47.82 166.14,47.68 165.46,47.68 165.21,47.43 164.82,47.43 164.75,47.49 164.75,49.22 165.03,49.5 166.12,49.5
+19VB on BOTTOM (solid shape): 135.71,113.02 136.83,113.02 136.89,112.96 136.89,110.89 136.77,110.77 134.94,110.77 134.72,110.55 134.15,110.55 134.15,111.08 133.72,111.08 133.72,110.55 133.04,110.55 132.77,110.81 132.77,112.47 133.14,112.83 133.95,112.83 134.53,113.41 135.32,113.41
+19VB on BOTTOM (solid shape): 168.21,104.31 168.21,103.29 168.09,103.17 164.24,103.17 162.6,101.52 161.28,101.52 161.28,100.98 161.03,100.98 161.03,101.51 160.48,101.51 160.48,100.98 160.24,100.98 160.24,101.51 159.13,101.51 158.82,101.82 158.82,103.29 159.96,104.44 168.09,104.44
+19VB on BOTTOM (solid shape): 190.53,51.37 190.72,51.18 191.04,51.18 191.3,51.43 191.3,52.13 193.26,52.13 195.17,50.22 195.17,49.53 194.48,48.83 189.02,48.83 188.25,48.06 188.25,45.46 187.61,44.83 184.12,44.83 183.55,45.4 183.55,50.92 184.76,52.13 190.53,52.13
+19VB on BOTTOM (solid shape): 17.42,38.38 20.23,38.38 20.24,38.38 20.24,37.85 20.67,37.85 20.67,38.4 21.03,38.4 21.26,38.16 21.26,36.66 20.98,36.38 18.83,36.38 18.06,35.62 16.31,35.62 15.99,35.94 15.99,38.49 16.16,38.66 17.14,38.66
+19VB on BOTTOM (solid shape): 91.12,141.82 91.35,141.6 91.35,138.93 90.9,138.49 88.74,138.49 88.49,138.74 88.49,139.73 87.93,139.73 87.88,139.78 87.88,140 88.43,140 88.43,140.5 87.88,140.5 87.88,140.73 87.91,140.75 88.49,140.75 88.49,141.68 88.64,141.82 90.11,141.82
+19VB on BOTTOM (solid shape): 209.8,54.03 209.84,54.03 210.11,53.94 210.39,54.03 210.62,54.03 210.98,53.67 210.98,53.5 211.03,53.35 211.03,51.54 210.85,51.37 207.93,51.37 207.81,51.49 207.81,53.65 208.19,54.03 209.79,54.03
+19VB on BOTTOM (solid shape): 172.58,80.7 173.28,79.74 173.99,78.77 173.99,78.01 175.36,76.64 175.36,75.94 174.91,75.5 174.34,75.5 174.15,75.31 172.12,75.31 169.34,78.09 169.34,78.48 169.96,79.1 170.37,79.52 170.37,79.55 170.02,79.9 170.2,80.08 170.55,79.72 170.58,79.72 170.94,80.08 170.94,80.12 170.59,80.47 170.76,80.64 171.11,80.29 171.15,80.29 171.65,80.79 172.49,80.79
+19VB on BOTTOM (solid shape): 168.65,58.01 168.88,57.78 169.5,57.78 169.5,56.54 169.46,56.54 169.13,56.24 169.18,55.8 169.04,55.65 168.96,55.46 168.96,55.45 168.25,54.73 167.42,54.73 167.26,54.89 167.26,55.34 167.82,55.34 167.82,55.82 167.26,55.82 167.26,56.62 167.17,56.71 167.17,58.86 168.65,58.86
+19VB on BOTTOM (solid shape): outline of 145 points within 48.55,123.38 54.26,139.38
+19VB on BOTTOM (solid shape): outline of 204 points within 35.85,112.33 54.26,129.47
+19VB on BOTTOM (solid shape): outline of 2123 points within 26.32,59.61 39.21,106.23
+19VB on IN1 (solid shape): 136,113.25 137.16,113.25 137.29,113.13 137.29,112.13 137.08,111.92 134.69,111.92 134.22,112.39 134.22,113.11 134.57,113.46 135.8,113.46
+19VB on IN1 (solid shape): outline of 562 points within 89.19,102.99 170.67,154.33
+19VB on IN1: 172.2,77.66 173.85,79.31 176.04,79.31 177.36,77.75 178.82,76.32 181,74.61 183.37,73.18 183.86,72.88 184.29,72.51 184.54,72.25 184.76,71.96 185.03,71.56 185.1,71.47 185.16,71.39 185.5,71.07 185.9,70.83 191.66,68.14 191.92,68.04 192.19,67.97 192.68,67.94 193.17,68.02 193.53,68.12 194.56,68.27 195.59,68.13 196.43,67.92 197.27,67.72 199.82,67.22 202.39,66.9 202.59,66.71 202.59,63.65 202.4,63.46 184.68,63.46 172.2,75.94
+19VB on VCC: 166.51,43.24 165.77,43.98 165.77,48.85 167.04,50.12 167.04,56.72 167.4,57.08 169.85,57.08 170.21,56.72 170.21,52.02 172.39,49.84 179.34,49.84 180.35,50.86 184.29,50.86 185.71,52.28 185.71,55.66 181.9,59.47 181.9,61.91 189.75,61.91 195.89,68.05 196.82,67.82 197.76,67.61 200.29,67.15 202.85,66.86 202.85,62.77 200.1,60.02 200.1,58.27 201.08,57.29 201.08,53.92 201.99,53.02 203.97,53.02 205.75,54.8 210.35,54.8 210.35,51.85 209.48,50.99 199.38,50.99 196,47.6 196,43.73 195.51,43.24
+19VB on VCC: outline of 97 points within 42.67,78.8 176.45,154.33
+19VB on IN2: outline of 109 points within 16.13,21.97 52.07,63.77
+19VB on IN3: 157.77,101.53 158.4,101.53 161.45,104.58 167.04,104.58 170.85,100.77 171.36,93.66 171.84,88.23 173.71,82.76 176.31,79.1 176.31,76.51 175.17,75.37 174.53,75.37 167.93,81.97 167.93,83.75 164.37,95.31 161.45,95.31 161.07,95.69 161.07,98.23 159.67,99.63 157.64,99.63 157.39,99.88 157.39,101.15
+19VB_1.2V on TOP (solid shape): 43.89,28.13 49.54,28.13 50.17,27.49 52.36,27.49 52.74,27.87 56.04,27.87 56.17,27.74 56.17,26.98 56.04,26.86 55.15,26.86 54.9,26.6 54.9,26.09 54.73,25.93 48.24,25.93 47.82,26.35 44.42,26.35 43.54,25.47 43.54,24.72 43.4,24.58 41.62,24.58 41.54,24.66 41.54,27.64 41.6,27.71 41.6,28.39 41.77,28.56 43.46,28.56
+19VB_1.2V on BOTTOM (solid shape): 46.26,29.52 46.26,27.29 43.77,27.29 43.39,26.91 43.39,25.54 43.39,25.54 43.39,24.73 43.2,24.54 41.54,24.54 41.44,24.64 41.44,28.4 41.59,28.55 43.1,28.55 43.26,28.72 43.26,28.91 43.26,28.91 43.26,29.4 43.27,29.4 43.67,29.4 43.67,28.64 43.71,28.6 43.71,28.15 43.92,27.93 44.23,27.93 44.44,28.14 44.44,29.33 44.17,29.6 43.87,29.6 43.67,29.4 43.27,29.4 43.64,29.77 46.01,29.77
+19VB_1.2V on IN1 (solid shape): 43.71,28.01 43.71,27.38 42.83,26.5 41.98,26.5 41.66,26.82 41.66,28.07 41.66,28.42 41.81,28.56 43.15,28.56
+19VB_1.05V on TOP (solid shape): 163.99,49.36 163.99,48.06 163.61,47.68 162.81,47.68 162.51,47.38 162.51,46.98 162.27,46.74 161.4,46.74 161.26,46.88 161.26,49.46 161.4,49.6 163.76,49.6
+19VB_1.05V on BOTTOM (solid shape): 163.93,49.08 163.93,47.37 163.7,47.14 161.85,47.14 161.64,46.93 161.64,44.54 161.62,44.51 161.3,44.51 161.26,44.54 161.26,49.53 161.32,49.59 163.42,49.59
+19VB_3V on TOP (solid shape): 18.45,42.13 18.45,40.83 18.32,40.7 17.43,40.7 17.33,40.8 17.33,42.26 18.32,42.26
+19VB_3V on BOTTOM (solid shape): 20.53,41.85 20.53,40.7 20.43,40.6 20.43,39.5 20.55,39.38 21.1,39.38 21.38,39.1 21.38,38.73 21.18,38.54 17.8,38.54 17.14,39.2 14.71,39.2 14.49,38.99 14.49,38.59 14.37,38.47 13.76,38.47 13.7,38.53 13.7,41.04 14,41.34 18.29,41.34 18.86,41.91 18.89,41.91 18.94,41.96 20.43,41.96
+19VB_5V on TOP (solid shape): 29.8,100.07 29.8,98.9 29.67,98.76 28.15,98.76 28.01,98.91 28.01,100.08 28.11,100.18 29.69,100.18
+19VB_5V on BOTTOM (solid shape): 26.08,103.04 26.08,102.76 26.35,102.49 27.35,102.49 27.35,101.94 27.92,101.94 27.92,102.49 28.16,102.49 28.16,101.94 28.71,101.94 28.71,101.95 28.71,102.48 29.07,102.49 29.73,101.83 29.73,98.91 29.59,98.78 28.4,98.78 28.3,98.68 26.89,98.68 26.5,98.29 25.04,98.29 24.97,98.37 24.97,99.43 25.43,99.9 25.43,103.06 25.5,103.12 26.01,103.12
+19VB_+1.35VGPU on TOP (solid shape): 140.58,110.3 140.58,108.54 140.37,108.33 138.91,108.33 138.7,108.54 138.7,110.38 138.75,110.43 140.45,110.43
+19VB_+1.35VGPU on BOTTOM (solid shape): 136.91,110.36 139.99,110.36 140.62,109.72 140.62,109.13 140.94,108.82 143.24,108.82 143.35,108.71 143.35,108.58 143.27,108.5 140.62,108.5 140.38,108.25 139.03,108.25 138.72,107.95 133.21,107.95 132.95,108.2 132.95,110.24 133.11,110.4 136.87,110.4
+19VB_CPU on TOP (solid shape): 167.97,84.47 167.97,82.88 167.88,82.79 166.05,82.79 165.93,82.91 165.93,84.54 165.94,84.55 167.89,84.55
+19VB_CPU on TOP (solid shape): 168.25,67.11 168.25,64.96 168.12,64.83 167.1,64.83 167.04,64.89 167.04,66.1 166.15,66.99 166.15,68.19 166.21,68.26 167.1,68.26
+19VB_CPU on TOP (solid shape): 169.77,81.72 169.77,79.1 170.86,78.01 169.5,76.64 166.59,76.64 165.52,77.72 165.52,82.35 165.7,82.54 168.95,82.54
+19VB_CPU on BOTTOM (solid shape): outline of 101 points within 163.82,64.56 172.3,85.72
+19VB_VGA on TOP (solid shape): 84.7,125.29 84.7,124.73 85.1,124.33 89.28,124.33 89.49,124.13 89.49,123.15 89.47,123.14 89.43,123.1 89.39,123.07 89.36,123.02 89.34,122.97 89.32,122.92 89.31,122.87 89.31,122.82 89.32,122.76 89.34,122.71 89.36,122.66 89.39,122.62 89.43,122.58 89.47,122.55 89.49,122.53 89.49,122.24 89.44,122.22 89.4,122.19 89.36,122.15 89.32,122.11 89.3,122.06 89.28,122.01 89.27,121.99 88.98,121.7 84.83,121.7 84.47,122.05 83.73,122.05 83.62,122.17 82.1,122.17 82.01,122.25 82.01,123.28 83.68,123.28 83.68,122.51 83.92,122.27 84.33,122.27 84.36,122.26 84.41,122.25 84.46,122.24 84.51,122.25 84.56,122.26 84.6,122.27 84.66,122.27 84.76,122.18 84.77,122.15 84.8,122.11 84.84,122.07 84.88,122.03 84.92,122 84.95,121.98 85,121.93 85.41,121.93 85.65,122.17 85.65,122.83 85.05,123.43 83.83,123.43 83.68,123.28 82.01,123.28 82.01,124.01 81.44,124.58 81.44,125.7 81.57,125.83 84.17,125.83
+19VB_VGA on TOP (solid shape): outline of 102 points within 80.73,134.26 89.16,138.57
+19VB_VGA on BOTTOM (solid shape): 88.2,141.74 88.2,141.73 88.3,141.63 88.3,140.93 87.74,140.93 87.74,140.37 88.3,140.37 88.3,140.13 87.74,140.13 87.74,139.59 88.3,139.59 88.3,138.21 88.53,137.98 89.36,137.98 89.36,136.16 88.93,135.73 85.15,135.73 84.69,135.28 84.69,134.5 84.35,134.16 81.26,134.16 81.09,134.34 81.09,135.63 81.33,135.87 81.55,135.87 81.55,135.87 81.63,135.87 81.86,136.11 81.86,137.79 83.92,137.79 83.92,136.89 84.19,136.61 84.31,136.61 84.34,136.6 84.4,136.6 84.46,136.6 84.5,136.61 85.48,136.61 85.68,136.81 85.68,137.77 85.43,138.02 84.14,138.02 83.92,137.79 81.86,137.79 81.86,140.37 82.12,140.63 85.78,140.63 85.8,140.65 86.2,141.05 86.2,141.74 86.28,141.81 88.12,141.81
+19VB_VGA on BOTTOM (solid shape): outline of 93 points within 81.44,121 89.19,125.83
+19VB_VGA on IN2: 78.27,126.21 78.27,139.25 79.01,140 79.86,140 80.11,139.89 80.36,140 86.66,140 88.3,138.36 88.3,134.81 87.6,134.11 84.55,134.11 84.11,133.66 84.11,126.42 85.38,125.15 85.38,124.29 84.57,123.48 81,123.48
+VCC_CORE on TOP (solid shape): outline of 1674 points within 118.98,64.19 158.66,85.53
+VCC_CORE on BOTTOM (solid shape): outline of 560 points within 144.56,64.45 159.39,85.21
+VCC_CORE on BOTTOM (solid shape): outline of 1073 points within 119.63,64.74 122.53,73.68
+VCC_CORE on BOTTOM (solid shape): outline of 1113 points within 130.12,65.12 134.31,73.7
+VCC_CORE on IN2 (solid shape): outline of 5535 points within 121.51,65.08 157.77,86.16
+VCC_CORE on VCC: 130.44,65.08 129.81,65.72 124.9,65.72 124.64,65.46 119.54,65.46 119.54,76.15 120.18,76.79 120.18,81.21 124,81.21 124.48,80.73 124.49,80.73 124.49,77.03 125.27,76.26 128.71,76.26 130.48,74.48 132.6,74.48 133,74.88 133,80.53 133.68,81.21 135.01,81.21 139.97,86.16 155.12,86.16 157.77,83.52 157.77,70.4 155.1,67.73 155.1,65.57 154.61,65.08
+VCC_CORE_GT on TOP (solid shape): outline of 666 points within 122.7,75.12 137.32,82.85
+VCC_CORE_GT on BOTTOM (solid shape): outline of 1124 points within 130.12,73.32 132.38,81.58
+VCC_CORE_GT on IN2 (solid shape): outline of 207 points within 124.99,76.02 131.3,81.2
+VCC_CORE_GT on VCC: 126.01,81.21 132.49,81.21 132.49,81.21 132.49,75.1 132.39,74.99 130.7,74.99 128.92,76.77 125.48,76.77 125,77.25 125,81.21 126,81.21
+VCC_GT on TOP (solid shape): outline of 1276 points within 121.28,81.63 153.4,107.02
+VCC_GT on BOTTOM (solid shape): 150.62,106.87 150.62,104.48 155.1,100 155.1,98.74 155.09,98.67 155.1,98.6 155.1,96.9 154.77,96.56 153.32,96.56 153.19,96.7 153.19,97.67 153.07,97.79 152.24,97.79 152.15,97.69 152.15,96.69 152.12,96.66 152.12,94.31 152,94.19 148.6,94.19 147.74,95.05 147.74,97.34 144.47,100.61 144.4,100.7 144.31,100.77 143.29,101.79 143.29,103.86 143.44,104.02 144.08,104.02 144.18,104.11 144.18,105.85 144.29,105.96 149.03,105.96 149.1,105.96 149.54,106.4 149.54,106.72 149.79,106.97 150.53,106.97
+VCC_GT on BOTTOM (solid shape): outline of 1828 points within 124.53,81.68 135.99,94.67
+VCC_GT on VCC: 120.18,81.72 120.18,90.38 123.86,94.06 123.86,104.07 150.8,104.07 152.31,102.57 152.31,86.67 139.76,86.67 134.8,81.72
+VCC_GT on IN2: 120.68,81.72 134.91,81.72 139.86,86.67 148.88,86.67 152.31,90.1 152.31,103.18 151.67,103.82 145.96,103.82 142.78,100.64 142.78,100.52 139.1,96.83 127.8,96.83 124.58,93.61 124.58,87.57 123.82,86.81 121.19,86.81 120.37,85.99 120.37,82.04
+VCC_SA on TOP (solid shape): 153.89,56.13 153.89,53.4 153.45,52.95 152.88,52.95 152.62,53.21 151.67,53.21 151.55,53.34 151.55,56.26 151.93,56.64 153.39,56.64
+VCC_SA on TOP (solid shape): outline of 383 points within 121.7,61.43 135.94,65.13
+VCC_SA on BOTTOM (solid shape): 155.74,56.13 155.74,54.3 155.61,54.17 154.73,54.17 154.73,53.41 155.63,53.41 155.63,52.42 155.51,52.3 152.92,52.3 152.82,52.41 152.82,52.99 152.61,53.2 151.66,53.2 151.48,53.37 151.48,56.32 151.93,56.76 155.1,56.76
+VCC_SA on BOTTOM (solid shape): outline of 231 points within 120.19,60.9 122.88,63.16
+VCC_SA on BOTTOM (solid shape): outline of 452 points within 130.12,61.51 132.38,64.94
+VCC_SA on VCC: 152.09,52.64 147.08,57.65 142.32,57.65 141.24,58.73 130.31,58.73 128.03,61.02 123.54,61.02 123.54,64.96 124.85,64.96 125.11,65.21 129.6,65.21 130.23,64.57 154.61,64.57 155.1,64.09 155.1,53.12 154.61,52.64
+VCC_SA on IN2: outline of 155 points within 121.19,52.64 155.1,65.21
+VCCIO on TOP (solid shape): 121.38,75.23 123.65,75.23 123.68,75.2 123.68,74.78 123.59,74.69 122.83,74.69 121.86,73.73 121.68,73.73 121.53,73.88 121.53,74.16 121.46,74.24 121.39,74.24 121.38,74.25 120.24,74.25 120.09,74.1 120.09,73.38 119.98,73.27 119.73,73.27 119.6,73.4 119.6,75.23 119.61,75.24 119.6,75.24 119.6,75.37 119.67,75.43 121.18,75.43
+VCCIO on TOP (solid shape): 121.35,64.62 121.52,64.45 121.96,64.45 122.13,64.62 123.28,64.62 123.37,64.53 123.37,64.03 123.44,63.96 123.44,63.26 123.34,63.16 122.41,63.16 122.03,63.54 121.58,63.54 121.58,63.54 120.64,63.54 120.59,63.59 120.59,64.12 120.59,64.13 120.59,64.15 120.5,64.24 120.06,64.24 119.68,64.24 119.61,64.3 119.61,64.56 119.68,64.62 120.35,64.62
+VCCIO on TOP (solid shape): outline of 225 points within 135.67,37.4 147.43,49.53
+VCCIO on BOTTOM (solid shape): outline of 211 points within 119.7,60.37 127.2,64.56
+VCCIO on BOTTOM (solid shape): outline of 223 points within 119.65,73.27 122.53,75.43
+VCCIO on VCC: 122.82,42.73 115.84,49.72 114.33,49.72 114.33,59.71 116.6,61.97 118.69,61.97 119.54,62.82 119.54,64.96 123.03,64.96 123.03,53.67 127.52,49.19 143.2,49.19 147.61,44.78 147.61,43.09 147.25,42.73
+VCCIO on IN2: 119.58,63.37 119.58,64.56 120.14,65.12 120.14,72.7 119.62,73.21 119.62,74.77 120.23,75.38 120.24,75.37 122.21,75.37 122.46,75.12 122.46,74.1 121.32,72.96 121.32,65.59 121.57,65.34 122.34,65.34 122.78,64.89 122.78,63.62 122.59,63.43 121.51,63.43 121.26,63.18 119.77,63.18
+VCCIO_OUT on TOP (solid shape): 149.01,40.7 149.77,40.7 149.89,40.57 149.89,39 149.89,38.99 149.89,37.78 149.86,37.74 149.23,37.74 149.13,37.75 149.04,37.74 148.03,37.74 147.58,38.19 147.58,41.06 147.72,41.21 148.5,41.21
+VCCPLL_OC on TOP (solid shape): outline of 622 points within 104.11,62.27 120.47,64.83
+VCCST on TOP (solid shape): outline of 343 points within 129.93,59.11 140.37,64.33
+VCCST on BOTTOM (solid shape): 123.48,109.6 123.48,108.45 123.41,108.39 122.78,108.39 122.65,108.52 122.65,109.34 122.97,109.66 123.41,109.66
+VCCST_OUT on BOTTOM (solid shape): 126.34,110.24 126.34,108.88 126.66,108.57 126.66,107.38 126.58,107.3 125.11,107.3 124.82,107.58 124.82,107.67 124.74,107.67 124.37,108.04 123.8,108.04 123.65,108.19 123.65,108.19 123.65,108.77 123.67,108.78 124.21,108.78 124.21,108.78 124.21,109.27 124.21,109.27 123.66,109.27 123.65,109.27 123.65,110.29 123.85,110.48 126.1,110.48
+VCCSTG on BOTTOM (solid shape): 123.08,105.55 123.5,105.55 123.5,104.54 124.06,104.54 124.06,104.54 124.06,104.37 124.06,104.36 123.51,104.36 123.51,104.36 123.51,103.91 123.06,103.46 121.73,103.46 121.51,103.68 121.51,105.34 121.86,105.7 121.95,105.71 122.02,105.74 122.9,105.74
+VCCSTG_OUT on BOTTOM (solid shape): 126.66,105.9 126.66,105.29 126.16,104.79 126.16,103.83 126.1,103.76 123.71,103.76 123.64,103.83 123.64,104.23 124.19,104.23 124.19,104.67 123.64,104.67 123.64,105.16 123.73,105.24 125.01,105.24 125.7,105.94 126.61,105.94
+VDD_CT on TOP (solid shape): 120.11,136.39 120.11,136.14 119.99,136.01 119.13,136.01 119.02,136.13 119.02,136.6 118.84,136.77 118.46,136.77 118.33,136.9 118.33,137.16 118.46,137.28 119.22,137.28
+VDD_CT on IN2: 113.08,135.17 112.99,135.23 113,135.33 113.07,135.51 113.03,135.69 112.73,135.86 112.44,135.68 112.37,135.63 112.28,135.66 112.21,135.74 112.21,137.46 112.59,137.84 118.04,137.84 118.23,137.78 118.42,137.84 119.45,137.84 120.08,137.2 120.08,135.74 119.51,135.17
+VDDR3 on TOP (solid shape): 120.11,133.85 120.11,133.35 119.92,133.16 119.67,133.16 118.59,134.23 118.31,134.23 118.15,134.39 118.15,134.74 118.28,134.87 119.1,134.87
GND on TOP (solid shape): 10.75,127 3.85,127 3.85,133.9 10.75,133.9
GND on TOP (solid shape): 126.46,125.22 126.4,125.15 125,125.15 124.68,125.47 124.68,126.3 125.13,126.74 126.46,126.74
GND on TOP (solid shape): 41.82,33.46 41.82,32.51 41.69,32.38 40.61,32.38 40.48,32.51 40.48,33.46 40.61,33.59 41.69,33.59
GND on TOP (solid shape): 96.48,57.29 96.48,55.71 96.39,55.62 94.84,55.62 94.59,55.87 94.59,57.22 94.77,57.4 96.37,57.4
GND on TOP (solid shape): 104.81,84.01 104.81,82.99 104.68,82.86 97.32,82.86 97.19,82.99 97.19,84.39 97.44,84.64 104.17,84.64
GND on TOP (solid shape): 120.62,135.5 120.62,134.49 120.43,134.3 119.92,134.3 119.54,134.68 119.54,135.5 119.67,135.63 120.49,135.63
GND on TOP (solid shape): 147.5,37.07 147.5,36.42 147,35.92 146.34,35.92 145.66,36.6 145.66,37.05 145.76,37.15 147.42,37.15
GND on TOP (solid shape): 149.26,84.26 149.26,81.47 149.2,81.4 148.43,81.4 148.24,81.59 148.24,84.07 148.5,84.32 149.2,84.32
GND on TOP (solid shape): 152.66,52.94 152.66,51.9 152.54,51.77 151.67,51.77 151.55,51.9 151.55,52.94 151.67,53.07 152.54,53.07
GND on TOP (solid shape): 165.71,52.83 165.71,50.8 165.52,50.6 162.09,50.6 161.91,50.78 161.91,52.97 161.95,53.01 165.53,53.01
GND on TOP (solid shape): 167.23,69.59 167.23,68.51 167.1,68.38 166.28,68.38 166.09,68.58 166.09,69.65 166.21,69.78 167.04,69.78
GND on TOP (solid shape): 198.85,61.46 198.85,60 198.73,59.88 197.65,59.88 197.52,60 197.52,61.53 197.65,61.65 198.66,61.65
GND on TOP (solid shape): 44.42,57.72 44.42,56.08 44,55.66 43.09,55.66 42.83,55.91 42.83,57.78 42.92,57.87 44.27,57.87
GND on TOP (solid shape): 51.52,33.52 51.52,32.54 51.32,32.33 48.72,32.33 48.16,32.89 48.16,33.55 48.2,33.58 51.46,33.58
GND on TOP (solid shape): 23.97,54.99 23.97,52.69 23.65,52.36 23.56,52.36 23.27,52.07 22.7,52.07 22.58,52.19 22.58,54.92 22.72,55.07 23.9,55.07
GND on TOP (solid shape): 84.42,74.41 84.42,70.87 83.92,70.37 80.6,70.37 80.17,70.8 80.17,74.23 80.55,74.61 84.22,74.61
GND on TOP (solid shape): 129.96,83.14 129.96,82.85 129.97,82.84 129.97,82.01 129.92,81.96 126.73,81.96 126.63,82.06 126.63,83.13 126.65,83.15 129.94,83.15
GND on TOP (solid shape): 131.91,65.73 132.1,65.73 132.39,65.44 132.39,65.05 132.17,64.83 131.32,64.83 131.28,64.87 131.28,65.83 131.32,65.87 131.76,65.87
GND on TOP (solid shape): 151.8,51.37 151.8,50.35 151.61,50.16 149.58,50.16 149.45,50.29 149.45,51.37 149.58,51.49 151.67,51.49
GND on TOP (solid shape): 154.67,113.37 154.67,112.53 154.59,112.45 153.22,112.45 153.09,112.58 153.09,113.42 153.22,113.55 154.49,113.55
GND on TOP (solid shape): 160.94,49.46 160.94,44.38 160.05,43.49 159.29,43.49 159.17,43.62 159.17,44.76 158.91,45.02 158.91,48.95 159.55,49.59 160.82,49.59
GND on TOP (solid shape): 171.74,43.75 172.75,43.75 172.88,43.62 172.88,40.32 172.63,40.06 170.6,40.06 170.34,40.32 170.34,43.75 170.6,44 171.48,44
GND on TOP (solid shape): 203.23,52.19 203.49,51.94 203.93,51.94 204.12,51.75 204.12,51.49 203.49,50.86 202.73,50.86 202.09,51.49 202.09,52.38 202.6,52.89 203.23,52.89
GND on TOP (solid shape): 26.77,25.05 26.77,23.16 26.03,22.42 26.03,20.67 25.96,20.6 23.61,20.6 23.46,20.76 23.46,21.64 24.59,22.77 24.59,24.69 25.06,25.16 26.66,25.16
GND on TOP (solid shape): 29.5,53.36 29.5,51.05 29.31,50.86 28.58,50.86 28.36,51.09 28.36,53.4 28.51,53.55 29.31,53.55
GND on TOP (solid shape): 37.7,29.57 37.7,27.94 37.67,27.92 36.05,27.92 35.98,27.98 35.98,29.63 36.05,29.7 37.57,29.7
GND on TOP (solid shape): 93.06,61.76 93.06,61.35 93.06,61.35 93.06,60.95 93.06,60.94 93.06,60.57 91.47,58.98 91.09,58.98 90.84,59.24 90.84,60.13 92.53,61.82 93,61.82
GND on TOP (solid shape): 133.04,69.99 133.04,69.56 132.89,69.41 132.07,69.41 131.78,69.12 130.87,69.12 130.84,69.15 130.84,69.78 130.97,69.91 131.61,69.91 131.86,70.16 132.87,70.16
GND on TOP (solid shape): 181.01,36.89 181.01,36.38 180.12,35.49 180.12,34.86 179.87,34.6 179.36,34.6 178.22,35.75 177.9,35.75 177.58,36.06 177.58,36.89 177.77,37.08 180.82,37.08
GND on TOP (solid shape): 11.1,108.9 4.05,108.9 4.05,114.8 4,115.07 3.85,115.29 3.85,115.65 11.1,115.65
GND on TOP (solid shape): 22.45,28.33 22.45,26.28 22.2,26.03 19.78,26.03 19.47,26.35 19.47,27.49 19.66,27.68 21.05,27.68 21.37,28 21.37,28.34 21.44,28.4 22.38,28.4
GND on TOP (solid shape): 197.27,46.86 197.27,40.95 196.69,40.38 193.2,40.38 192.95,40.64 192.95,41.84 193.26,42.16 194.98,42.16 195.3,42.48 195.3,46.92 195.42,47.05 197.07,47.05
GND on TOP (solid shape): 115.22,139.5 115.22,138.68 115.16,138.62 113.83,138.62 113.76,138.68 113.76,139.25 113.6,139.41 112.71,139.41 112.37,139.76 112.37,140.27 112.68,140.58 114.14,140.58
GND on TOP (solid shape): 159.09,108.19 159.09,102.98 157.77,101.66 154.21,101.66 150.95,104.92 150.95,106.89 151.08,107.02 152.1,107.02 152.46,107.37 152.46,108.24 152.66,108.44 158.83,108.44
GND on TOP (solid shape): 203.87,47.68 204.06,47.49 205.39,47.49 205.46,47.43 205.46,46.92 205.65,46.73 206.47,46.73 206.85,46.35 206.85,44.06 206.79,44 203.36,44 202.92,44.45 202.92,48 203.17,48.26 203.87,48.26
GND on TOP (solid shape): 26.83,105.74 26.83,102.93 26.58,102.67 24.67,102.67 24.55,102.8 24.55,103.75 24.29,104.01 23.47,104.01 23.34,104.14 23.34,105.81 23.62,106.09 26.48,106.09
GND on TOP (solid shape): 36.61,35.94 37.44,35.94 37.56,35.81 37.56,35.68 37.63,35.62 37.63,34.96 37.12,34.45 37.12,32.86 37.04,32.79 35.53,32.79 35.47,32.85 35.47,34.45 36.05,35.03 36.05,35.39 36.6,35.94
GND on TOP (solid shape): 70.2,113.44 70.2,109.9 69.7,109.4 68.56,109.4 68.04,108.89 66.3,108.89 66.2,108.99 66.2,109.52 65.43,110.3 65.43,110.66 65.64,110.88 67.29,110.88 67.68,111.27 67.68,113.43 67.77,113.52 70.12,113.52
GND on TOP (solid shape): 40.03,14.74 40.03,8.3 39.89,8.16 38.57,8.16 38.45,8.28 38.45,9.65 38.6,9.79 38.76,9.79 39.06,10.09 39.06,12.47 38.77,12.76 38.33,12.76 38.23,12.85 38.24,12.86 38.24,14.71 38.58,15.04 39.72,15.04
GND on TOP (solid shape): 42.31,30.16 42.43,30.13 42.54,30.16 43.04,30.16 43.14,30.06 43.14,28.8 43.03,28.68 41.73,28.68 41.6,28.82 41.6,29.52 41.92,29.84 41.92,30.04 42.03,30.16
GND on TOP (solid shape): 104.11,64.57 104.11,63.24 104.05,63.18 100.32,63.18 100.24,63.18 99.94,62.88 99.9,62.88 99.72,62.71 99.52,62.71 99.47,62.66 99.47,62.03 99.35,61.92 98.77,61.92 98.58,62.11 98.58,64.45 99.03,64.89 103.79,64.89
GND on TOP (solid shape): 37.27,16.9 37.27,15.77 37.1,15.59 37.1,15.19 36.9,15 36.3,15 36.14,15.15 35.48,15.15 35.37,15.26 35.37,15.88 35.51,16.01 35.87,16.01 36.16,16.3 36.16,17.46 36.71,17.46
GND on TOP (solid shape): 129.69,85.85 129.69,85.09 129.56,84.96 126.8,84.96 125.98,84.13 124.11,84.13 123.77,84.48 123.77,85.34 123.77,85.34 123.77,85.38 123.85,85.45 126.04,85.45 126.23,85.64 126.23,85.84 126.28,85.89 129.64,85.89
GND on TOP (solid shape): 27.27,7.3 27.27,7.04 27.66,6.66 35.4,6.66 35.47,6.6 35.47,6.15 33.75,4.44 31.72,4.44 29.94,6.22 27.27,6.22 26.64,6.85 26.64,7.3 26.7,7.36 27.21,7.36
GND on TOP (solid shape): 105.44,60.7 105.44,59.94 105.42,59.94 105.42,58.92 105.44,58.92 105.44,58.61 105.57,58.48 105.57,58.1 105.44,57.97 102.97,57.97 102.84,58.1 102.84,58.67 102.99,58.81 102.99,59.87 103.08,59.97 103.55,59.97 103.8,60.21 103.8,60.62 103.99,60.81 105.33,60.81
GND on TOP (solid shape): 177.18,58.65 177.19,58.65 177.32,58.52 178.31,58.52 178.45,58.38 178.45,53.44 177.98,52.97 175.72,52.97 175.61,52.99 175.5,52.97 173.32,52.97 172.92,52.57 172.47,52.57 172.31,52.72 172.31,58.35 172.5,58.54 173.01,58.54 173.31,58.85 176.98,58.85
GND on TOP (solid shape): 166.91,64.32 169.2,64.32 169.33,64.19 169.33,59.49 168.98,59.15 162.24,59.15 162.09,59.3 162.09,61.53 160.05,63.56 159.04,63.56 158.53,64.07 158.53,64.7 158.66,64.83 159.04,64.83 159.42,64.45 160.18,64.45 160.44,64.19 161.96,64.19 162.34,64.57 162.34,65.46 163.1,66.23 163.1,66.86 163.23,66.99 164.25,66.99
GND on TOP (solid shape): 121.77,68.13 121.81,68.13 130.02,68.13 130.02,67.56 130.27,67.31 132.24,67.31 132.37,67.18 132.37,66.92 132.24,66.8 122.21,66.8 121.95,67.05 121.57,67.05 121.32,66.8 120.43,66.8 120.37,66.86 120.37,68.07 120.43,68.13 121.72,68.13
GND on TOP (solid shape): 127.67,131.07 127.67,129.04 127.67,128.77 127.66,128.75 127.07,128.75 126.84,128.53 126.41,128.53 126.21,128.72 126.21,129.66 125.51,130.36 125.51,130.39 125.51,130.65 125.51,130.68 125.83,131 126.2,131 126.83,131 127.09,131.25 127.49,131.25
GND on TOP (solid shape): 71.5,34.97 71.5,34.93 72.34,34.93 72.34,34.94 72.43,34.94 72.6,34.77 72.6,33.22 72.35,32.98 71.65,32.98 71.27,33.36 69.24,33.36 68.99,33.11 67.75,33.11 67.47,32.84 67.47,32.13 67.34,32 66.46,32 66.33,32.13 66.33,34.08 66.58,34.33 70.56,34.33 70.81,34.57 70.81,35.26 70.89,35.34 71.13,35.34
GND on TOP (solid shape): 119.01,129.28 119.44,129.28 119.56,129.16 119.58,129.16 119.6,129.15 120.02,129.15 120.04,129.16 120.05,129.16 120.19,129.3 121.01,129.3 121.15,129.16 121.15,128.57 120.53,127.94 120.07,127.94 119.82,128.2 119.78,128.24 119.74,128.28 119.62,128.4 118.72,128.4 118.47,128.65 118.47,129.14 117.96,129.65 117.96,130.01 118.02,130.07 118.22,130.07
GND on TOP (solid shape): 30.41,98.14 30.41,94.12 30.11,93.81 28.01,93.81 27.48,94.34 27.48,95.07 27.41,95.13 27.41,95.14 27.35,95.22 27.27,95.28 27.24,95.31 27.2,95.31 27.1,95.33 27,95.31 26.99,95.31 25.41,95.31 25.23,95.49 25.23,97.65 26.08,98.49 30.07,98.49
GND on TOP (solid shape): 87.58,149.46 87.58,148.69 87.41,148.52 83.54,148.52 83.03,148.01 83.03,144.65 82.46,144.08 82.46,140.08 82.23,139.85 80.65,139.85 80.3,140.2 80.3,142.68 77.81,145.17 74.71,145.17 74.71,145.65 74.15,145.65 74.15,145.17 73.91,145.17 73.91,145.65 73.33,145.65 73.33,145.17 72.3,145.17 72.13,145.34 72.13,149.59 72.25,149.71 87.34,149.71
GND on TOP (solid shape): 127.44,138.43 127.44,138.43 127.5,138.37 127.5,137.5 127.66,137.35 127.66,135.06 127.6,135 127.09,135 127.07,135.02 127.07,135.41 126.93,135.56 126.91,135.56 126.83,135.63 126.48,135.63 126.4,135.54 125.78,135.54 125.65,135.67 125.65,136.05 125.47,136.23 125.47,136.58 125.55,136.66 125.55,137.89 125.64,137.98 126.78,137.98 126.78,138.36 126.91,138.49 127.38,138.49
GND on TOP (solid shape): 126.79,144.95 126.79,144.47 126.27,143.95 125.64,143.95 125.19,143.51 125.19,139.63 125.13,139.57 123.1,139.57 123.03,139.63 123.03,141.07 123.52,141.56 123.69,141.56 124.11,141.98 124.11,143 123.54,143.57 122.46,143.57 122.03,144 121.71,144 121.33,144.38 121.33,144.97 121.63,145.27 126.47,145.27
GND on TOP (solid shape): 167.79,34.37 167.79,33.26 167.78,33.25 167.78,32.65 167.74,32.61 167.3,32.57 167.25,32.12 167.08,31.96 166.11,31.96 165.41,32.66 165.41,32.97 165.76,33.32 165.76,33.4 166.07,33.71 166.07,34.27 166.26,34.46 167.7,34.46
GND on TOP (solid shape): 37.37,27.64 37.37,26.86 37.64,26.59 38.1,26.59 38.77,25.92 38.77,24.44 38.64,24.32 38.39,24.32 38.26,24.44 38.26,25.59 38.02,25.83 38.01,26.2 37.63,26.23 37.62,26.22 37.14,26.71 37.14,27.64 37.19,27.69 37.32,27.69
GND on TOP (solid shape): 63.33,31.57 63.33,30.88 63.23,30.76 63.2,30.6 63.2,29.99 63.33,29.86 63.33,29.31 63.18,29.01 63.33,28.72 63.33,27.87 63.03,27.56 61.96,27.56 61.77,27.75 61.77,28.97 62.13,29.33 62.13,30.94 61.77,31.3 61.77,31.53 61.86,31.62 63.27,31.62
GND on TOP (solid shape): 121.57,63.37 121.57,62.66 122.03,62.21 122.03,62.2 122.1,62.13 122.1,61.23 122.06,61.19 121.51,61.19 121.35,61.03 121.35,60.63 121.23,60.51 121.23,60.41 121.21,60.37 120.72,59.88 120.57,59.88 120.24,60.21 120.21,60.24 120.18,60.26 120.18,60.61 120.18,60.62 120.2,60.72 120.19,60.83 120.18,60.86 120.46,61.14 120.46,61.17 120.76,61.47 120.76,62.53 120.59,62.7 120.59,63.41 120.6,63.42 121.53,63.42
GND on TOP (solid shape): 172.61,33.19 173.03,33.19 173.17,33.04 173.17,31.59 174.06,30.7 174.06,30.3 173.91,30.11 173.92,29.87 173.93,29.83 173.26,29.16 171.83,29.16 171.82,29.16 171.73,29.18 171.63,29.16 171.62,29.16 171.58,29.16 171.42,29.32 171.42,30.03 171.36,30.09 171.19,30.09 171.06,30.22 171.06,30.98 171.25,31.17 171.25,33.07 171.44,33.26 172.54,33.26
GND on TOP (solid shape): 211.92,48.51 212.8,48.51 212.89,48.41 212.89,47.78 212.64,47.52 212.62,47.52 212.44,47.52 212.44,47.37 212.42,47.34 212.42,47.07 212.34,47 211.84,47 211.66,47.43 211.21,47.32 211.03,47.5 211.03,48.58 211.12,48.68 211.75,48.68
GND on TOP (solid shape): 132.89,93.09 132.89,92.89 133.07,92.71 133.51,92.71 133.64,92.83 133.64,93.02 133.77,93.16 133.95,93.16 134.13,92.98 134.13,91.05 134.05,90.97 133.9,90.97 133.77,91.1 133.77,91.33 133.7,91.41 131.34,91.41 131.29,91.36 131.29,88.43 131.79,87.93 131.79,86.52 131.79,86.47 131.79,86.38 131.74,86.33 131.39,86.33 131.34,86.38 131.34,87.09 130.27,88.16 130.14,88.16 129.86,88.43 129.86,92.4 130.02,92.55 131.06,92.55 131.28,92.78 131.28,93.21 131.38,93.31 132.67,93.31
GND on TOP (solid shape): 203.93,56.07 203.93,54.86 203.89,54.86 203.67,54.64 203.79,54.35 203.79,54.35 203.93,54.2 203.93,53.78 203.68,53.53 203.32,53.53 203.29,53.54 203.27,53.58 202.99,53.86 202.71,53.58 202.7,53.54 202.66,53.53 202.09,53.53 201.84,53.78 201.84,56.13 202.09,56.38 203.62,56.38
GND on TOP (solid shape): 164.49,87.43 165.57,87.43 165.99,87.01 165.99,86.08 165.76,85.85 165.76,83.02 165.11,82.37 165.11,78.29 164.67,77.85 159.84,77.85 159.27,78.42 159.27,79.21 157.9,80.58 157.9,85.65 157.96,85.79 157.96,85.94 157.95,85.97 158.53,86.55 161.51,86.55 162.2,87.23 162.37,87.07 162.37,87.04 162.84,86.82 162.62,87.29 162.59,87.29 162.43,87.46 162.48,87.51 164.41,87.51
GND on TOP (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.51,20.63 4.7,20.63 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on TOP (solid shape): 46.77,25.76 47.09,25.57 47.4,25.76 47.42,25.79 47.76,25.79 47.86,25.69 47.86,24.83 47.52,24.48 47.52,23.87 47.31,23.67 44.96,23.67 44.32,23.54 43.78,23.18 43.33,22.74 39.71,22.74 39.47,22.98 39.52,23.14 39.47,23.3 39.47,24.1 39.6,24.24 43.71,24.24 43.84,24.11 44.18,24.11 44.43,24.36 44.43,25.53 44.69,25.79 46.76,25.79
GND on TOP (solid shape): 165.8,109.64 169.11,112.75 171.29,112.75 171.34,112 171.65,107 171.7,106.25 169.8,106.25 169.13,106.25 168.98,106.25 168.83,106.26
GND on TOP (solid shape): 97.5,153 97.65,152.65 98,152.5 100,152.5 100.35,152.65 100.5,153 100.5,154.4 103,154.4 103,153.4 103,153.35 103,150 99.3,150 99.3,150.01 96.24,151.11 95,154.11 95,154.4 97.5,154.4
GND on TOP (solid shape): 130.58,65.79 130.58,65.59 130.24,65.26 129.09,65.26 128.95,65.26 128.82,65.13 128.82,64.75 128.7,64.62 128.44,64.62 128.31,64.75 128.31,65.07 128.12,65.26 127.68,65.26 127.55,65.13 127.55,64.75 127.44,64.64 127.21,64.64 127.21,64.64 127.15,64.64 127.04,64.75 127.04,65.07 126.87,65.25 126.44,65.25 126.27,65.08 126.27,65.01 126.27,64.76 126.15,64.64 125.89,64.64 125.76,64.76 125.76,65.07 125.6,65.24 125.57,65.26 125.12,65.26 125,65.15 125,64.96 125,64.79 124.85,64.64 124.56,64.64 124.37,64.45 124.37,63.32 124.28,63.24 123.83,63.24 123.75,63.31 123.75,63.86 123.5,64.11 123.5,64.58 123.33,64.75 122.08,64.75 121.91,64.57 121.57,64.57 121.4,64.75 120.41,64.75 120.35,64.8 120.35,65.22 120.42,65.29 124.32,65.29 124.52,65.49 124.52,65.81 124.63,65.92 130.44,65.92
GND on TOP (solid shape): 151.19,108.54 151.19,107.56 150.95,107.32 149.65,107.32 149.32,106.99 149.32,106.42 149.2,106.29 144.05,106.29 143.67,105.91 143.67,101.09 141.39,98.8 139.42,98.8 138.97,98.36 136.05,98.36 134.65,99.75 134.65,101.66 135.04,102.04 135.04,103.61 133.89,104.76 133.89,105.79 141.92,105.79 141.92,105.73 141.93,105.68 141.95,105.63 141.98,105.59 142.01,105.54 142.05,105.51 142.1,105.48 142.14,105.45 142.19,105.44 142.25,105.43 142.3,105.43 142.35,105.44 142.4,105.45 142.45,105.48 142.5,105.51 142.54,105.54 142.57,105.59 142.6,105.63 142.62,105.68 142.63,105.73 142.63,105.79 142.63,105.84 142.62,105.89 142.6,105.94 142.57,105.99 142.54,106.03 142.5,106.07 142.45,106.1 142.4,106.12 142.35,106.13 142.3,106.14 142.25,106.14 142.19,106.13 142.14,106.12 142.1,106.1 142.05,106.07 142.01,106.03 141.98,105.99 141.95,105.94 141.93,105.89 141.92,105.84 141.92,105.79 133.89,105.79 133.89,107.32 134.77,108.2 142.46,108.2 143.35,107.31 146.59,107.31 146.88,107.6 148.65,107.6 149.11,108.06 149.11,108.52 149.28,108.69 151.04,108.69
GND on TOP (solid shape): 159.29,93.97 159.29,93.57 159.57,93.29 161.76,93.29 161.83,93.21 161.83,92.58 162.09,92.32 168.08,92.32 168.44,91.97 168.44,88.96 168.2,88.72 165.53,88.72 165.49,88.81 165.54,88.89 165.61,89.44 165.06,89.39 165,89.35 164.93,89.35 164.6,89.32 164.44,89.02 164.44,88.94 164.36,88.86 164.36,87.85 164.28,87.77 162.2,87.77 162.02,87.95 162.02,88.72 161.71,89.02 157.44,89.02 156.94,89.52 156.94,91.28 156.57,91.65 155.67,91.65 155.53,91.78 155.53,93.03 155.84,93.34 157.44,93.34 157.59,93.5 157.59,93.82 158.08,94.3 158.96,94.3
GND on TOP (solid shape): outline of 103 points within 121.51,128.03 127.41,137.35
GND on TOP (solid shape): outline of 83 points within 124,59.86 132.38,62.65
GND on TOP (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,45.11 15.15,45.11 15.15,45.02 14.7,44.58 13.19,44.58 13.04,44.43 13.04,37.83 14.69,37.83 15.11,37.41 15.11,36.26 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.72 13.7,34.83 14.2,35.6 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.2,46.8 13.7,47.57 13.7,48.12 14.16,48.12
GND on TOP (solid shape): 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 10.87,66.75 11.68,65.94 11.68,64.82 15.1,61.4 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75
GND on TOP (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on TOP (solid shape): outline of 94 points within 80.27,122.3 94.52,133.84
GND on TOP (solid shape): 6.41,118.4 6.68,118.4 6.77,118.31 6.77,118.09 10.05,114.8 10.05,109.77 9.24,108.96 4.51,108.96 4.51,108.3 4.45,107.94 4.29,107.62 4.29,107.02 6.05,105.26 10.05,105.26 10.14,105.26 10.23,105.25 13.14,105.25 13.88,104.5 13.88,103.77 13.42,103.31 11.07,103.31 10.71,102.95 10.71,102.63 10.25,102.63 10.25,103.43 10.29,103.44 10.74,104.22 10.05,104.8 3.76,104.8 2,104.8 1.79,104.89 1.7,105.1 1.7,107.3 1.79,107.51 2,107.6 3.35,107.6 3.57,107.63 3.76,107.73 3.98,107.98 4.05,108.3 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,117.61 0.2,117.73 4.11,117.73 4.11,117.66 4.11,117.54 4.72,116.93 5.32,117.54 5.32,117.66 5.25,117.96 5.04,118.18 5.09,118.23 5.1,118.25 5.12,118.27 5.38,118.54 5.38,118.63 5.51,118.75 6.05,118.75
GND on TOP (solid shape): outline of 85 points within 56.75,43.94 80.06,46.63
GND on TOP (solid shape): outline of 1303 points within 117.75,65.93 128.63,93.4
GND on TOP (solid shape): outline of 337 points within 0.21,0.21 228.19,155.29
GND on BOTTOM (solid shape): 89.35,44.57 89.35,41.05 88.4,40.1 85.09,40.1 84.62,40.57 84.62,44.46 84.81,44.65 89.28,44.65
GND on BOTTOM (solid shape): 90.92,31.86 90.92,30.54 90.67,30.28 89.44,30.28 89.32,30.41 89.32,32.27 89.44,32.39 90.38,32.39
GND on BOTTOM (solid shape): 104.43,119.25 104.43,116.52 104.17,116.26 101.7,116.26 101.38,116.58 101.38,119.31 101.51,119.44 104.24,119.44
GND on BOTTOM (solid shape): 146.72,97.72 146.72,95.18 146.59,95.05 143.93,95.05 143.04,95.94 143.04,97.72 143.29,97.98 146.47,97.98
GND on BOTTOM (solid shape): 152.66,52.94 152.66,51.9 152.54,51.77 151.67,51.77 151.55,51.9 151.55,52.94 151.67,53.07 152.54,53.07
GND on BOTTOM (solid shape): 29.65,52.93 29.65,51.06 29.45,50.86 28.53,50.86 28.41,50.99 28.41,53.21 28.42,53.21 28.55,53.34 29.24,53.34
GND on BOTTOM (solid shape): 34.39,112.64 34.39,111.13 33.43,110.17 30.24,110.17 29.82,110.59 29.82,112.83 29.88,112.9 34.13,112.9
GND on BOTTOM (solid shape): 41.96,34.19 41.96,32.11 41.63,31.77 40.02,31.77 39.92,31.87 39.92,31.9 38.75,33.07 38.75,34.79 41.36,34.79
GND on BOTTOM (solid shape): 52.69,112.22 52.69,108.35 52.17,107.83 46.84,107.83 46.57,108.11 46.57,111.98 46.93,112.34 52.56,112.34
GND on BOTTOM (solid shape): 43.14,30.01 43.14,28.77 43.05,28.68 41.5,28.68 41.45,28.73 41.45,30.04 41.58,30.17 42.97,30.17
GND on BOTTOM (solid shape): 151.8,51.37 151.8,50.35 151.61,50.16 149.58,50.16 149.45,50.29 149.45,51.37 149.58,51.49 151.67,51.49
GND on BOTTOM (solid shape): 152.94,61.59 152.94,59.3 152.82,59.18 149.2,59.18 149.01,59.37 149.01,61.65 149.26,61.91 152.62,61.91
GND on BOTTOM (solid shape): 154.67,113.37 154.67,112.53 154.59,112.45 153.22,112.45 153.09,112.58 153.09,113.42 153.22,113.55 154.49,113.55
GND on BOTTOM (solid shape): 165.71,52.83 165.71,50.8 165.52,50.6 162.09,50.6 161.91,50.78 161.91,52.64 162.05,52.77 164.38,52.77 164.56,52.95 165.58,52.95
GND on BOTTOM (solid shape): 199.68,62.03 199.68,60.13 199.42,59.88 197.65,59.88 197.52,60 197.52,62.16 197.65,62.29 199.42,62.29
GND on BOTTOM (solid shape): 25.05,77.78 25.05,76.89 24.93,76.77 24.93,76.13 24.75,75.95 23.36,75.95 23.27,76.05 23.27,77.78 23.4,77.91 24.93,77.91
GND on BOTTOM (solid shape): 153.45,89.34 153.45,87.43 153.13,87.12 148.43,87.12 147.35,86.04 144.81,86.04 144.43,86.42 144.43,89.34 144.76,89.67 153.12,89.67
GND on BOTTOM (solid shape): 170.02,84.1 170.02,83.06 169.44,82.48 168.92,82.48 168.88,82.52 168.88,84.09 169,84.21 169.66,84.21 169.91,84.21
GND on BOTTOM (solid shape): 22.06,34.68 22.06,33.2 22.28,32.98 22.77,32.98 23.04,32.7 23.04,31.63 22.78,31.36 20.96,31.36 20.7,31.63 20.7,34.71 20.8,34.81 21.93,34.81
GND on BOTTOM (solid shape): 25.18,104.28 25.18,99.94 24.99,99.75 24.55,99.75 24.48,99.82 24.48,103.87 24.58,103.96 24.58,104.39 24.66,104.48 24.98,104.48
GND on BOTTOM (solid shape): 51.52,33.46 51.52,32.56 51.31,32.35 48.74,32.35 48.14,32.95 48.14,32.98 48.14,33.49 48.26,33.61 51.37,33.61
GND on BOTTOM (solid shape): 161.01,49.46 161.01,44.64 160.87,44.51 159.23,44.51 158.97,44.76 158.97,48.38 159.14,48.55 159.14,49.19 159.55,49.59 160.88,49.59
GND on BOTTOM (solid shape): 28.36,105.94 28.36,104.65 26.32,104.65 25.11,103.44 24.55,103.44 24.55,103.48 23.97,104.05 23.49,104.05 23.36,104.17 23.36,105.52 23.97,106.13 28.17,106.13
GND on BOTTOM (solid shape): 101.32,143.82 104.3,143.82 104.43,143.7 104.43,141.16 104.24,140.97 100.94,140.97 100.05,141.85 100.05,144.01 100.24,144.2 100.94,144.2
GND on BOTTOM (solid shape): 120.26,129.31 120.59,129.31 120.9,129 120.9,128.38 120.97,128.31 120.97,128.11 120.86,127.99 120.65,127.99 120.47,127.81 119.59,127.81 119.29,128.11 119.29,128.35 120.26,129.32
GND on BOTTOM (solid shape): 168.28,102.85 168.28,102.4 168.29,101.49 168.33,100.57 168.33,100.55 168.21,100.44 164.66,100.44 164.47,100.63 164.47,102.85 164.59,102.98 168.15,102.98
GND on BOTTOM (solid shape): 168.47,50.83 168.37,50.73 167.8,50.73 167.67,50.86 167.67,52.59 167.57,52.69 166.66,52.69 166.57,52.78 166.57,52.94 166.65,53.02 167.55,53.02 167.68,53.15 167.68,53.7 168.47,53.7
GND on BOTTOM (solid shape): 196.25,48.38 196.25,47.81 197.27,46.79 197.27,40.95 196.69,40.38 193.2,40.38 193.07,40.51 193.07,41.97 193.26,42.16 194.98,42.16 195.3,42.48 195.3,48.57 195.42,48.7 195.93,48.7
GND on BOTTOM (solid shape): 204,58.16 204,57.65 203.93,57.59 203.36,57.59 203.11,57.34 203.11,56.76 203.74,56.13 203.74,52.32 203.55,52.13 202.41,52.13 202.03,52.51 202.03,56.13 202.54,56.64 202.54,58.16 202.6,58.22 203.93,58.22
GND on BOTTOM (solid shape): 166.59,71.88 166.59,70.35 167.23,69.72 167.23,68.51 167.1,68.38 166.21,68.38 166.09,68.51 166.09,69.65 165.52,70.23 164.88,70.23 164.5,70.61 164.5,71.69 164.75,71.94 166.53,71.94
GND on BOTTOM (solid shape): 171.61,46.16 171.61,44 171.99,43.62 172.88,43.62 173.01,43.49 173.01,42.73 173.39,42.35 173.39,39.17 171.74,37.52 166.79,37.52 166.53,37.78 166.53,40.7 166.91,41.08 169.83,41.08 170.34,41.59 170.34,46.03 170.6,46.29 171.48,46.29
GND on BOTTOM (solid shape): 186.47,56.07 186.47,53.34 186.41,53.27 185.07,53.27 185.01,53.34 185.01,54.67 184.82,54.86 184.5,54.86 184.12,55.24 184.12,55.88 184.22,55.97 184.33,56.03 184.4,56.13 186.41,56.13
GND on BOTTOM (solid shape): 23.21,59.88 23.21,57.02 23.9,56.33 23.9,52.21 23.69,52 21.68,52 21.43,52.25 21.43,52.81 21.42,52.82 21.42,52.89 20.54,53.77 20.54,53.78 19.96,54.36 19.96,58.94 19.66,59.24 19.66,60.83 19.85,61.02 22.07,61.02
GND on BOTTOM (solid shape): 79.79,122.23 79.79,122.04 79.73,121.98 78.27,121.98 78.09,121.8 78.09,120.92 78.17,120.83 79.72,120.83 79.81,120.74 79.81,120.63 79.69,120.51 79.69,118.99 79.62,118.92 76.9,118.92 76.88,118.95 76.88,121.54 77.63,122.3 79.73,122.3
GND on BOTTOM (solid shape): 24.67,83.75 24.67,83.75 25.44,83.75 26.54,82.65 26.54,79.49 26.47,79.43 23.43,79.43 23.15,79.15 23.15,78.8 23.04,78.69 22.52,78.69 22.41,78.81 22.41,80.48 22.09,80.79 22.09,84.06 22.24,84.21 24.22,84.21
GND on BOTTOM (solid shape): 30.53,97.2 30.53,93.86 30.36,93.69 28.66,93.69 28.5,93.73 28.35,93.71 28.29,93.71 28.18,93.82 28.18,96.8 27.96,97.02 27.58,97.02 27.55,97.05 26.47,97.05 26.02,96.61 25.11,96.61 24.73,96.99 24.69,97.03 23.5,97.03 22.84,96.37 22.33,96.37 22.15,96.55 22.15,96.75 22.71,97.31 24.63,97.31 25,97.69 26.56,97.69 26.62,97.75 28.01,97.75 28.28,98.02 29.71,98.02
GND on BOTTOM (solid shape): 142.37,92.83 142.37,91.18 141.99,90.8 141.96,90.78 141.91,90.76 141.6,90.96 141.36,90.67 140.43,90.67 140.31,90.8 140.31,91.24 140.05,91.5 140.05,92.64 139.99,92.71 139.61,92.71 139.54,92.77 139.54,93.34 139.57,93.37 141.83,93.37
GND on BOTTOM (solid shape): 17.64,43.16 18.88,43.16 19.29,43.57 20.56,43.57 20.94,43.19 21.8,43.19 21.85,43.24 21.89,43.24 21.99,43.34 21.99,43.38 22.06,43.44 22.06,43.75 22.18,43.87 22.44,43.87 22.51,43.8 22.51,43.52 22.34,43.34 22.31,43.34 21.85,42.88 20.84,42.88 20.48,42.53 18.78,42.53 18.7,42.45 17.92,42.45 16.95,41.49 13.88,41.49 13.42,41.03 13.42,38.59 13.31,38.48 12.27,38.48 12.15,38.6 12.15,43.51 12.97,44.33 16.47,44.33
GND on BOTTOM (solid shape): 119.24,112.42 119.24,112.2 119.14,112.1 119.14,111.26 119.27,111.12 119.27,111.08 119.35,111.08 119.43,111.07 119.51,111.08 119.72,111.08 119.74,111.06 122.78,111.06 122.81,111.02 122.81,110.31 122.75,110.25 122.05,110.25 121.86,110.05 117.75,110.05 117.7,110.1 115.22,110.1 115.01,110.32 115.01,110.95 115.12,111.06 118.32,111.06 118.35,111.08 118.55,111.08 118.63,111.07 118.71,111.08 118.79,111.08 118.92,111.21 118.92,112.12 118.83,112.22 118.83,112.43 118.93,112.53 119.13,112.53
