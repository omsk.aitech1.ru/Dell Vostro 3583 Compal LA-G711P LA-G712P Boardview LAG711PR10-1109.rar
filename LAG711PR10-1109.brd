# Allegro board LAG711PR10-1109.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D39: length 66.4
  IN3 w0.089: v1(116.65,76.23) 116.65,76.23 116.64,76.23 116.32,76.23 115.73,75.64 114.12,75.64 111.99,73.51 105.54,73.51
  IN3 w0.117: 105.54,73.51 104.86,72.83 101,72.83 95.27,67.1 89.58,67.1 87.97,65.49 84.89,65.49 83.26,63.87 78.12,63.87 77.49,63.24 65.32,63.24 64.34,64.21 61.18,64.21 61.07,64.32 61.07,64.68 61.34,64.95 v1(61.52,64.95)
  BOTTOM w0.102: v1(116.65,76.23) 116.7,76.23 116.91,76.01 UC1.AJ32 ; v1(61.52,64.95) 61.11,64.54 59.51,64.54 59.31,64.74 59.04,64.74
  BOTTOM w0.112: JDIMM2.174 59.04,64.74
DDR_B_D40: length 67.4
  IN3 w0.089: v1(117.33,72.59) 117.25,72.59 116.81,73.02 116.28,73.02 113.18,69.92 112.38,69.92 112.01,70.29 105.64,70.29 105.55,70.2 105.55,70.06 105.46,69.97 105.28,69.97 105.2,70.06 105.2,70.13 105.11,70.22 104.61,70.22
  IN3 w0.117: 104.61,70.22 104.39,70.22 104.28,70.11 104.28,70.03 104.16,69.91 103.92,69.91 103.81,70.03 103.81,70.11 103.69,70.22 103.43,70.22 96.87,63.66 92.28,63.66 90.73,62.11 87.17,62.11 84.24,59.19 83.55,59.19 83.44,59.31 83.44,59.43 83.32,59.55 83.08,59.55 82.97,59.43 82.97,59.31 82.85,59.19 82.62,59.19 82.5,59.31 82.5,59.43 82.38,59.55 82.15,59.55 82.03,59.43 82.03,59.31 81.92,59.19 81.68,59.19 81.57,59.31 81.57,59.43 81.45,59.55 81.22,59.55 81.1,59.43 81.1,59.31 80.98,59.19 63.01,59.19 62.9,59.3 62.9,59.47 v1(63.04,59.61)
  BOTTOM w0.102: UC1.AR31 117.56,72.35 v1(117.33,72.59)
  BOTTOM w0.112: JDIMM2.191 63.92,60.49 v1(63.04,59.61)
DDR_B_D41: length 67.1
  IN3 w0.089: v1(116.65,72.6) 116.11,72.6 112.96,69.45 106.46,69.45 106.29,69.61 106.21,69.61
  IN3 w0.117: 106.21,69.61 103.27,69.61 97.01,63.34 92.41,63.34 90.86,61.79 87.3,61.79 84.38,58.87 62.5,58.87 62.38,58.99 62.38,59.11 62.26,59.22 62.03,59.22 61.91,59.11 61.91,58.99 61.79,58.87 61.19,58.87 61.07,58.99 61.07,59.28 61.4,59.61 v1(61.52,59.61)
  BOTTOM w0.102: v1(116.65,72.6) 116.91,72.34 UC1.AR32
  BOTTOM w0.112: JDIMM2.190 59.32,60.74 59.63,60.43 60.7,60.43 v1(61.52,59.61)
DDR_B_D42: length 70.3
  IN3 w0.089: v1(117.97,70.76) 117.57,70.36 117.02,70.36 116.6,69.95 115.68,69.95 114.68,68.95 114.68,68.61 113.87,67.8 112.99,67.8 112.63,67.44 111.89,67.44 111.79,67.54 104.45,67.54 104.03,67.13
  IN3 w0.117: v1(61.52,56.63) 61.09,56.21 61.09,55.98 61.31,55.76 84.41,55.76 87.08,58.44 88.94,58.44 89.06,58.56 89.06,59.25 89.17,59.37 90.33,59.37 90.45,59.25 90.45,58.56 90.56,58.44 91.36,58.44 92.44,59.52 94.32,59.52 95.92,61.13 98.8,61.13 101.45,63.77 101.45,64.54 104.03,67.13
  BOTTOM w0.089: v1(117.97,70.76) 118.02,70.65 UC1.AV30
  BOTTOM w0.112: v1(61.52,56.63) 61.08,57.06 59.48,57.06 59.31,57.24 JDIMM2.204
DDR_B_D43: length 70.3
  IN3 w0.089: v1(118.6,70.76) 118.06,70.23 117.68,70.23 117.64,70.19 117.09,70.19 116.68,69.77 115.75,69.77 114.86,68.88 114.86,68.48 113.92,67.55 113.17,67.55 112.72,67.1 111.86,67.1 111.62,67.35 104.71,67.35 104.26,66.9
  IN3 w0.117: 104.26,66.9 101.77,64.41 101.77,63.64 98.8,60.67 95.92,60.67 94.45,59.2 92.57,59.2 91.49,58.12 90.08,58.12 89.96,58.24 89.96,58.93 89.85,59.05 89.61,59.05 89.49,58.93 89.49,58.24 89.38,58.12 87.21,58.12 84.54,55.44 61.18,55.44 v1(59.99,56.63)
  BOTTOM w0.089: UC1.AV29 118.66,70.65 v1(118.6,70.76)
  BOTTOM w0.112: JDIMM2.208 59.6,56.24 v1(59.99,56.63)
DDR_B_D44: length 68.8
  IN3 w0.089: v1(117.97,72.59) 117.97,72.87 117.88,72.96 117.19,72.96 116.87,73.27 116.28,73.27 113.68,70.67 112.26,70.67 112.05,70.47 103.82,70.47 103.78,70.43 103.74,70.43
  IN3 w0.117: v1(64.56,59.61) 64.67,59.51 65.15,59.51 65.27,59.63 65.27,59.75 65.39,59.87 65.62,59.87 65.74,59.75 65.74,59.63 65.85,59.51 66.09,59.51 66.2,59.63 66.2,59.75 66.32,59.87 66.55,59.87 66.67,59.75 66.67,59.63 66.79,59.51 68.1,59.51 68.22,59.63 68.22,59.75 68.34,59.87 68.57,59.87 68.69,59.75 68.69,59.63 68.81,59.51 69.87,59.51 69.98,59.63 69.98,59.75 70.1,59.87 70.34,59.87 70.45,59.75 70.45,59.63 70.57,59.51 70.8,59.51 70.92,59.63 70.92,59.75 71.04,59.87 71.27,59.87 71.39,59.75 71.39,59.63 71.5,59.51 77.75,59.51 77.87,59.63 77.87,59.75 77.98,59.87 78.22,59.87 78.33,59.75 78.33,59.63 78.45,59.51 78.68,59.51 78.8,59.63 78.8,59.75 78.92,59.87 79.15,59.87 79.27,59.75 79.27,59.63 79.38,59.51 79.62,59.51 79.73,59.63 79.73,59.75 79.85,59.87 80.09,59.87 80.2,59.75 80.2,59.63 80.32,59.51 80.55,59.51 80.67,59.63 80.67,59.75 80.79,59.87 84.47,59.87 87.04,62.43 89.61,62.43 89.72,62.55 89.72,62.74 89.84,62.86 90.07,62.86 90.19,62.74 90.19,62.55 90.31,62.43 90.6,62.43 90.81,62.64 90.81,62.81 90.29,63.32 90.29,63.49 90.46,63.65 90.62,63.65 91.14,63.14 91.3,63.14 91.46,63.29 91.46,63.49 91.16,63.78 91.16,63.9 91.25,63.98 96.74,63.98 103.19,70.43 103.74,70.43
  BOTTOM w0.102: UC1.AR30 118.21,72.34 v1(117.97,72.59)
  BOTTOM w0.112: v1(64.56,59.61) 64.69,59.49 JDIMM2.195
DDR_B_D45: length 69.1
  IN3 w0.089: v1(118.6,72.59) 118.22,72.2 116.35,72.2 115.98,71.83 115.98,71.41 115.64,71.07 114.85,71.07 113.03,69.24 106.33,69.24
  IN3 w0.117: v1(59.99,59.61) 59.52,59.61 59.41,59.49 59.41,58.67 59.52,58.55 84.51,58.55 87.43,61.47 91,61.47 92.55,63.02 97.14,63.02 103.36,69.24 106.33,69.24
  BOTTOM w0.102: UC1.AR29 118.86,72.32 v1(118.6,72.59)
  BOTTOM w0.112: v1(59.99,59.61) 59.58,59.61 59.45,59.74 JDIMM2.194
DDR_B_D46: length 68.5
  IN3 w0.089: 106.23,68.54 106.33,68.63 111.69,68.63 111.85,68.47 112.74,68.47 112.93,68.27 113.63,68.27 114.18,68.82 114.18,69.3 115.2,70.31 116.18,70.31 v1(116.59,70.72)
  IN3 w0.117: 106.23,68.54 105.88,68.18 104.18,68.18 97.77,61.77 93.07,61.77 91.52,60.22 87.95,60.22 84.73,56.99 83.23,56.99 83.12,56.87 83.12,56.52 83,56.4 82.77,56.4 82.65,56.52 82.65,56.87 82.53,56.99 82.26,56.99 82.14,56.87 82.14,56.52 82.03,56.4 79.45,56.4 79.34,56.52 79.34,56.87 79.22,56.99 78.99,56.99 78.87,56.87 78.87,56.52 78.75,56.4 78.52,56.4 78.4,56.52 78.4,56.87 78.28,56.99 78.05,56.99 77.93,56.87 77.93,56.52 77.82,56.4 71.69,56.4 71.58,56.52 71.58,56.87 71.46,56.99 71.23,56.99 71.11,56.87 71.11,56.52 70.99,56.4 70.76,56.4 70.64,56.52 70.64,56.87 70.52,56.99 70.29,56.99 70.17,56.87 70.17,56.52 70.06,56.4 68.89,56.4 68.78,56.52 68.78,56.87 68.66,56.99 68.43,56.99 68.31,56.87 68.31,56.52 68.19,56.4 66.8,56.4 66.68,56.52 66.68,56.87 66.56,56.99 66.33,56.99 66.21,56.87 66.21,56.52 66.09,56.4 65.86,56.4 65.74,56.52 65.74,56.87 65.63,56.99 65.39,56.99 65.28,56.87 65.28,56.52 65.16,56.4 64.79,56.4 v1(64.56,56.63)
  BOTTOM w0.102: v1(116.59,70.72) 116.76,70.36 UC1.AV32
  BOTTOM w0.112: v1(64.56,56.63) 64.7,56.49 66.45,56.49 JDIMM2.207
DDR_B_D47: length 68.9
  IN3 w0.089: v1(117.33,70.76) 117.11,70.54 116.94,70.54 116.53,70.13 115.6,70.13 114.5,69.03 114.5,68.71 113.79,68 112.96,68 112.7,68.25 112.14,68.25 111.67,67.78 104.24,67.78 103.81,67.35
  IN3 w0.117: v1(63.04,56.63) 63.58,56.08 84.27,56.08 86.95,58.76 87.69,58.76 87.8,58.88 87.8,59.57 87.92,59.69 88.15,59.69 88.27,59.57 88.27,58.88 88.39,58.76 88.62,58.76 88.74,58.88 88.74,59.57 88.85,59.69 90.65,59.69 90.77,59.57 90.77,58.88 90.88,58.76 91.22,58.76 92.31,59.84 94.19,59.84 95.79,61.45 98.67,61.45 101.13,63.9 101.13,64.67 103.81,67.35
  BOTTOM w0.102: v1(117.33,70.76) 117.33,70.54 UC1.AV31
  BOTTOM w0.112: v1(63.04,56.63) 63.9,57.49 JDIMM2.203
DDR_B_D48: length 66
  IN3 w0.089: 105.86,65.99 105.99,66.12 110.62,66.12 110.73,66.24 113.06,66.24 113.18,66.12 113.67,66.12 115.76,68.21 115.97,68.21 116.69,68.93 v1(116.69,68.94)
  IN3 w0.117: 105.86,65.99 99.01,59.14 96.04,59.14 93.85,56.95 87.7,56.95 84.46,53.72 62.46,53.72 v1(61.52,54.66)
  BOTTOM w0.102: v1(116.69,68.94) 116.69,68.94 UC1.BA32
  BOTTOM w0.112: JDIMM2.212 60.94,55.24 v1(61.52,54.66)
DDR_B_D49: length 66.8
  IN3 w0.089: v1(117.33,68.94) 116.94,69.33 116.54,69.33 116.31,69.1 116.31,68.89 115.87,68.45 115.75,68.45 114.23,66.94 113.2,66.94 112.72,66.46 111.82,66.46 111.36,66.92 105.27,66.92 105.25,66.9 105.23,66.9 105.02,66.69 105.02,66.66 104.94,66.58 104.94,66.23
  IN3 w0.117: v1(63.04,54.66) 63.54,54.16 65.38,54.16 65.82,54.6 77.44,54.6 77.94,54.09 79.53,54.09 80.04,54.6 84.89,54.6 87.56,57.27 93.72,57.27 95.9,59.46 98.88,59.46 104.94,65.52 104.94,66.23
  BOTTOM w0.089: UC1.BA31 v1(117.33,68.94)
  BOTTOM w0.112: v1(63.04,54.66) 63.87,55.49 JDIMM2.211
DDR_B_D50: length 68.2
  IN3 w0.089: 109.46,63.09 109.89,63.09 110.89,64.09 111.33,64.09 111.78,64.54 111.8,64.54 111.83,64.57 113.83,64.57 115.15,65.89 115.76,65.89 116.6,66.73 116.79,66.73 117.16,67.09 v1(117.29,67.09)
  IN3 w0.117: 109.46,63.09 108.91,63.09 108.53,62.71 106.94,62.71 105.47,61.24 104.14,61.24 102.75,59.85 102.75,59.32 99.84,56.41 97.34,56.41 95.38,54.46 87.88,54.46 84.71,51.29 78.79,51.29 78.68,51.17 78.68,50.98 78.56,50.86 78.33,50.86 78.21,50.98 78.21,51.17 78.09,51.29 77.84,51.29 77.72,51.17 77.72,50.74 77.61,50.62 71.89,50.62 71.77,50.74 71.77,51.17 71.66,51.29 71.42,51.29 71.31,51.17 71.31,50.74 71.19,50.62 70.95,50.62 70.84,50.74 70.84,51.17 70.72,51.29 70.49,51.29 70.37,51.17 70.37,50.74 70.25,50.62 68.53,50.62 68.42,50.74 68.42,51.17 68.3,51.29 68.07,51.29 67.95,51.17 67.95,50.74 67.83,50.62 67.6,50.62 67.48,50.74 67.48,51.17 67.37,51.29 67.13,51.29 67.02,51.17 67.02,50.74 66.9,50.62 64.82,50.62 v1(64.56,50.88)
  BOTTOM w0.102: UC1.BD31 117.36,67.06 117.31,67.08 v1(117.29,67.09)
  BOTTOM w0.112: v1(64.56,50.88) 64.56,51.4 65.16,51.99 JDIMM2.225
DDR_B_D51: length 68.2
  IN3 w0.089: 110.28,64.38 111.17,64.38 111.55,64.76 113.76,64.76 115.09,66.09 115.7,66.09 116.64,67.03 v1(116.64,67.09)
  IN3 w0.117: v1(63.04,50.88) 62.88,50.88 62.51,51.25 62.51,51.49 62.62,51.61 65.04,51.61 65.16,51.49 65.16,51.06 65.28,50.94 65.51,50.94 65.63,51.06 65.63,51.49 65.75,51.61 65.98,51.61 66.1,51.49 66.1,51.17 66.21,51.05 66.45,51.05 66.56,51.17 66.56,51.49 66.68,51.61 84.58,51.61 87.75,54.78 95.25,54.78 97.2,56.73 99.71,56.73 102.43,59.46 102.43,60.28 104.69,62.54 105.96,62.54 106.56,63.14 108.16,63.14 109.4,64.38 110.28,64.38
  BOTTOM w0.102: UC1.BD32 116.76,66.97 v1(116.64,67.09)
  BOTTOM w0.112: JDIMM2.229 65.3,50.99 64.77,50.46 63.46,50.46 v1(63.04,50.88)
DDR_B_D52: length 67
  IN3 w0.089: v1(117.97,68.94) 117.86,68.94 117.48,69.32 117.21,69.32 117.02,69.5 116.46,69.5 115.98,69.02 115.98,68.89 115.75,68.66 115.71,68.66 114.19,67.14 113.15,67.14 112.74,66.74 111.85,66.74 111.48,67.11 105.18,67.11 104.63,66.56 104.63,66.53
  IN3 w0.117: 104.63,66.53 104.56,66.45 104.56,65.59 98.75,59.78 95.77,59.78 94.35,58.36 94.18,58.36 93.86,58.68 93.69,58.68 93.53,58.51 93.53,58.35 93.85,58.03 93.85,57.86 93.58,57.6 92.93,57.6 92.81,57.71 92.81,58.24 92.7,58.35 92.46,58.35 92.35,58.24 92.35,57.71 92.23,57.6 87.43,57.6 84.76,54.92 79.63,54.92 79.51,54.8 79.51,54.53 79.4,54.41 79.16,54.41 79.04,54.53 79.04,54.8 78.93,54.92 78.69,54.92 78.58,54.8 78.58,54.53 78.46,54.41 78.23,54.41 78.11,54.53 78.11,54.8 77.99,54.92 65.69,54.92 65.43,54.66 v1(64.56,54.66)
  BOTTOM w0.089: UC1.BA30 v1(117.97,68.94)
  BOTTOM w0.112: JDIMM2.215 66.45,54.49 65.14,54.49 64.98,54.66 v1(64.56,54.66)
DDR_B_D53: length 68.1
  IN3 w0.089: v1(118.6,68.94) 118.08,68.41 116.54,68.41 116.11,67.99 115.79,67.99 113.7,65.89 113.13,65.89 113,66.02 110.83,66.02 110.71,65.89 106.27,65.89 106.17,65.8
  IN3 w0.117: 106.17,65.8 99.2,58.82 96.17,58.82 93.38,56.03 87.23,56.03 84.59,53.4 61.25,53.4 v1(59.99,54.66)
  BOTTOM w0.089: UC1.BA29 v1(118.6,68.94)
  BOTTOM w0.112: v1(59.99,54.66) 59.57,54.24 JDIMM2.216
DDR_B_D54: length 69.1
  IN3 w0.089: 109.57,62.29 109.7,62.29 110.99,63.58 113.72,63.58 114.12,63.98 114.12,64.36 115.27,65.5 115.88,65.5 116.67,66.3 116.89,66.3 117.15,66.55 118.03,66.55 v1(118.6,67.12)
  IN3 w0.117: 109.57,62.29 108.4,61.11 106.83,61.11 105.06,59.35 103.68,59.35 100.11,55.77 97.6,55.77 95.65,53.82 88.15,53.82 84.31,49.98 60.22,49.98 59.99,50.21 v1(59.99,50.88)
  BOTTOM w0.102: v1(118.6,67.12) UC1.BD29
  BOTTOM w0.112: v1(59.99,50.88) 59.63,51.24 JDIMM2.228
DDR_B_D55: length 68.8
  IN3 w0.089: v1(117.97,67.12) 117.58,66.73 117.07,66.73 117.06,66.72 117.05,66.72 116.8,66.47 116.6,66.47 115.81,65.68 115.19,65.68 113.88,64.37 111.86,64.37 111.41,63.92 110.97,63.92 109.74,62.69 109.29,62.69 109.2,62.6
  IN3 w0.117: v1(61.52,50.88) 62.09,50.3 78.99,50.3 79.11,50.42 79.11,50.81 79.23,50.92 79.46,50.92 79.58,50.81 79.58,50.59 79.69,50.48 79.93,50.48 80.04,50.59 80.04,50.81 80.2,50.97 84.84,50.97 88.01,54.14 95.51,54.14 97.47,56.09 99.98,56.09 104.01,60.13 104.01,60.12 105.06,60.12 107.06,62.12 108.72,62.12 109.2,62.6
  BOTTOM w0.102: v1(117.97,67.12) UC1.BD30
  BOTTOM w0.112: JDIMM2.224 60.15,52.24 v1(61.52,50.88)
DDR_B_D56: length 69.3
  IN3 w0.089: v1(117.33,65.29) 116.94,65.68 116.56,65.68 115.73,64.85 115.24,64.85 114.66,64.28 114.66,63.79 113.35,62.48 112.5,62.48
  IN3 w0.117: 112.5,62.48 111.1,62.48 106.77,58.15 103.8,58.15 100.58,54.93 97.95,54.93 95.4,52.38 87.9,52.38 84.66,49.14 81.18,49.14 81.06,49.02 81.06,48.73 80.94,48.61 80.05,48.61 79.94,48.73 79.94,49.02 79.82,49.14 79.59,49.14 79.47,49.02 79.47,48.73 79.35,48.61 79.12,48.61 79,48.73 79,49.02 78.88,49.14 78.65,49.14 78.53,49.02 78.53,48.73 78.42,48.61 64.58,48.61 64.36,48.83 63.85,48.83 63.63,48.61 62.73,48.61 62.64,48.7 62.64,49.11 62.77,49.24 v1(63.04,49.24)
  BOTTOM w0.089: UC1.BG31 v1(117.33,65.29)
  BOTTOM w0.112: JDIMM2.233 65.19,49.99 65.03,49.83 63.63,49.83 v1(63.04,49.24)
DDR_B_D57: length 68.9
  IN3 w0.089: v1(116.71,65.31) 116.02,64.62 115.33,64.62 114.89,64.18 114.89,63.77 113.25,62.13 111.89,62.13 110.61,60.85 110.31,60.85
  IN3 w0.117: v1(61.52,49.24) 61.06,48.78 61.06,48.51 61.28,48.29 61.74,48.29 61.86,48.41 61.86,48.71 61.97,48.82 62.21,48.82 62.32,48.71 62.32,48.41 62.44,48.29 84.45,48.29 88.22,52.06 95.53,52.06 97.53,54.06 100.16,54.06 102.77,56.67 105.73,56.67 109.92,60.85 110.31,60.85
  BOTTOM w0.102: v1(116.71,65.31) 116.71,65.26 UC1.BG32
  BOTTOM w0.112: v1(61.52,49.24) 60.52,50.24 JDIMM2.232
DDR_B_D58: length 68.3
  IN3 w0.089: 111.88,59.83 112.79,59.83 114.47,61.51 114.47,62.02 115.69,63.24 115.99,63.24 116.23,63.48 v1(116.69,63.47)
  IN3 w0.117: 111.88,59.83 111.03,58.99 111.03,58.87 110.26,58.1 109.4,58.1 106.39,55.09 103.43,55.09 100.01,51.68 97.38,51.68 95.52,49.81 88.5,49.81 84.99,46.3 80.59,46.3 80.47,46.18 80.47,46.15 80.36,46.03 80.12,46.03 80.01,46.15 80.01,46.18 79.89,46.3 79.66,46.3 79.54,46.18 79.54,45.89 79.42,45.78 79.19,45.78 79.07,45.89 79.07,46.18 78.95,46.3 78.72,46.3 78.6,46.18 78.6,45.89 78.49,45.78 78.25,45.78 78.14,45.89 78.14,46.18 78.02,46.3 77.79,46.3 77.67,46.18 77.67,45.89 77.55,45.78 71.7,45.78 71.59,45.89 71.59,46.18 71.47,46.3 71.23,46.3 71.12,46.18 71.12,45.89 71,45.78 70.77,45.78 70.65,45.89 70.65,46.18 70.53,46.3 70.3,46.3 70.18,46.18 70.18,45.89 70.07,45.78 69.03,45.78 68.91,45.89 68.91,46.17 68.79,46.29 68.56,46.29 68.44,46.17 68.44,45.89 68.32,45.78 67.07,45.78 66.96,45.89 66.96,46.18 66.84,46.3 66.61,46.3 66.49,46.18 66.49,45.89 66.37,45.78 66.14,45.78 66.02,45.89 66.02,46.18 65.91,46.3 65.67,46.3 65.55,46.18 65.55,45.89 65.44,45.78 64.98,45.78 v1(64.56,46.19)
  BOTTOM w0.076: UC1.BK32 v1(116.69,63.47)
  BOTTOM w0.112: v1(64.56,46.19) 64.77,45.99 JDIMM2.249
DDR_B_D59: length 69.2
  IN3 w0.089: v1(117.33,63.47) 117.23,63.47 117.03,63.27 116.76,63 115.81,63 114.71,61.9 114.71,61.85 114.71,61.49 112.84,59.63 112.19,59.63 111.86,59.3
  IN3 w0.117: v1(63.04,46.19) 63.77,45.46 80.79,45.46 80.91,45.57 80.91,45.86 81.02,45.98 81.26,45.98 81.37,45.86 81.37,45.57 81.49,45.46 81.72,45.46 81.84,45.57 81.84,45.86 81.96,45.98 82.19,45.98 82.31,45.86 82.31,45.57 82.43,45.46 82.66,45.46 82.78,45.57 82.78,45.86 82.89,45.98 83.13,45.98 83.24,45.86 83.24,45.57 83.36,45.46 83.59,45.46 83.71,45.57 83.71,45.86 83.83,45.98 85.12,45.98 88.63,49.49 95.65,49.49 97.52,51.36 100.15,51.36 103.56,54.77 106.52,54.77 109.47,57.72 110.65,57.72 111.41,58.48 111.41,58.85 111.86,59.3
  BOTTOM w0.076: UC1.BK31 v1(117.33,63.47)
  BOTTOM w0.112: v1(63.04,46.19) 63.84,46.99 JDIMM2.245
DDR_B_D60: length 69.5
  IN3 w0.089: 110.63,60.53 110.74,60.53 112.11,61.91 113.23,61.91 113.25,61.94 113.31,61.94 115.12,63.74 115.12,64.11 115.43,64.42 116.1,64.42 116.52,64.84 118.15,64.84 v1(118.6,65.29)
  IN3 w0.117: v1(59.99,49.24) 59.91,49.16 59.91,48.19 60.14,47.97 84.71,47.97 88.48,51.74 95.67,51.74 97.67,53.74 100.3,53.74 102.9,56.35 105.87,56.35 110.05,60.53 110.44,60.53 110.44,60.53 110.63,60.53
  BOTTOM w0.089: UC1.BG29 v1(118.6,65.29)
  BOTTOM w0.112: v1(59.99,49.24) 58.25,49.24 JDIMM2.236
DDR_B_D61: length 69.4
  IN3 w0.089: v1(117.97,65.29) 117.6,65.66 117.24,65.66 117.01,65.89 116.51,65.89 115.68,65.05 115.19,65.05 114.33,64.19 114.33,63.71 113.35,62.73 110.87,62.73
  IN3 w0.117: v1(64.56,49.24) 64.79,49.46 64.95,49.46 65.07,49.34 65.07,49.05 65.18,48.93 65.42,48.93 65.54,49.05 65.54,49.34 65.65,49.46 65.89,49.46 66,49.34 66,49.05 66.12,48.93 66.35,48.93 66.47,49.05 66.47,49.34 66.59,49.46 66.83,49.46 66.99,49.3 66.99,49.14 67.11,49.02 67.35,49.02 67.47,49.14 67.47,49.34 67.59,49.46 68.23,49.46 68.35,49.34 68.35,49.07 68.46,48.95 68.7,48.95 68.82,49.07 68.82,49.34 68.93,49.46 69.65,49.46 69.76,49.34 69.76,49.05 69.88,48.93 70.11,48.93 70.23,49.05 70.23,49.34 70.35,49.46 70.58,49.46 70.7,49.34 70.7,49.05 70.82,48.93 71.05,48.93 71.17,49.05 71.17,49.34 71.28,49.46 71.53,49.46 71.64,49.34 71.64,49.05 71.76,48.93 71.99,48.93 72.11,49.05 72.11,49.34 72.23,49.46 77.56,49.46 77.68,49.34 77.68,49.05 77.79,48.93 78.03,48.93 78.15,49.05 78.15,49.34 78.26,49.46 84.53,49.46 88.36,53.29 95.86,53.29 97.82,55.25 100.45,55.25 103.67,58.47 104.93,58.47 107.05,60.59 108.72,60.59 110.87,62.73
  BOTTOM w0.089: UC1.BG30 v1(117.97,65.29)
  BOTTOM w0.112: JDIMM2.237 64.81,48.99 v1(64.56,49.24)
DDR_B_D62: length 70.2
  IN3 w0.089: v1(117.97,63.47) 117.6,63.11 117.12,63.11 117.1,63.09 116.79,62.78 116.78,62.77 115.89,62.77 114.89,61.77 114.89,61.42 112.89,59.42 112.55,59.42
  IN3 w0.117: 112.55,59.42 111.79,58.67 111.79,57.9 108.31,54.41 104.68,54.41 102.46,52.19 101.44,52.19 98.41,49.17 88.76,49.17 84.73,45.14 61.5,45.14 61.1,45.54 61.1,45.95 61.34,46.19 v1(61.52,46.19)
  BOTTOM w0.076: UC1.BK30 v1(117.97,63.47)
  BOTTOM w0.112: v1(61.52,46.19) 61.06,45.74 JDIMM2.250
DDR_B_D63: length 70.6
  IN3 w0.089: 112.61,58.86 112.62,58.86 112.68,58.92 112.75,58.92 115.14,61.31 115.14,61.77 115.96,62.59 116.86,62.59 116.96,62.7 116.96,62.7 117.17,62.92 117.66,62.92 117.8,63.05 118.18,63.05 v1(118.6,63.47)
  IN3 w0.117: 112.61,58.86 112.14,58.4 112.14,57.8 108.44,54.09 104.81,54.09 102.59,51.87 101.57,51.87 101.37,51.68 101.37,51.51 101.52,51.37 101.52,51.2 101.35,51.04 101.19,51.04 101.04,51.18 100.88,51.18 98.55,48.85 88.9,48.85 84.86,44.82 61.37,44.82 v1(59.99,46.19)
  BOTTOM w0.076: UC1.BK29 v1(118.6,63.47)
  BOTTOM w0.112: JDIMM2.246 59.44,46.74 v1(59.99,46.19)
DDR_B_DQS0: length 80.2
  IN3 w0.089: 116.7,98.85 116.7,98.83 116.71,98.83 116.71,98.77 116.74,98.74 116.74,98.63 117.33,98.04 117.33,95.13 117.32,95.12 117.32,95.12 118.35,94.09 118.35,92.99 118.7,92.64 118.86,92.64 118.86,92.64 119.5,92.64 122.14,89.99 122.14,88.73 122.06,88.64 121.94,88.64 121.77,88.81 121.7,88.81 121.63,88.88 v1(121.63,89.09)
  IN3 w0.117: 116.7,98.85 116.7,99.23 116.68,99.25 116.68,102.19 114.87,104 111.61,104 110.14,102.53 79.78,102.53 79.66,102.41 79.66,102.28 79.42,102.04 78.72,102.04 78.48,102.28 78.48,102.41 78.36,102.53 67.59,102.53 67.43,102.68 61.64,102.68 61.52,102.56 61.52,102.33 61.6,102.25 61.6,102.17 61.7,102.07 v1(61.95,102.07)
  BOTTOM w0.076: v1(121.63,89.09) 121.69,89.03 121.89,89.03 122.05,89.19 UC1.G24
  BOTTOM w0.112: JDIMM2.34 59.28,101.74 59.42,101.88 59.57,101.88 60.14,101.31 61.47,101.31 61.72,101.57 61.72,101.85 v1(61.95,102.07)
DDR_B_DQS1: length 81.5
  IN3 w0.117: v1(63.42,107.26) 63.18,107.26 63.06,107.37 63.06,107.58 63.18,107.7 72.72,107.7 72.84,107.58 72.84,107.55 73.08,107.31 73.6,107.31 73.84,107.55 73.84,107.58 73.96,107.7 77.43,107.7 77.54,107.58 77.54,107.43 77.78,107.19 78.31,107.19 78.55,107.43 78.55,107.58 78.67,107.7 80.42,107.7 81.47,106.66 87.9,106.66 88.94,107.7 116.49,107.7 123.2,100.99 123.2,97.55 123.19,97.54 123.19,95.03 123.07,94.92 122.88,94.92 122.86,94.94 122.81,94.94 122.7,95.05 v1(122.7,95.2)
  BOTTOM w0.076: UC1.D23 122.44,91.25 122.44,91.67 122.31,91.8 122.31,92.04 122.27,92.15 122.27,92.42 122.31,92.51 122.31,93.55 122.12,93.75 122.12,94.75 122.33,94.97 122.63,94.97 122.7,95.04 v1(122.7,95.2)
  BOTTOM w0.112: v1(63.42,107.26) 63.17,107.51 63.17,107.87 63.32,108.01 64.26,108.01 65.13,107.15 65.44,107.15 65.6,106.99 JDIMM2.13
DDR_B_DQS2: length 67.7
  IN3 w0.089: 112.68,93.91 113,93.6 113,92.36 114.32,91.04 114.32,90.68 115.64,89.36 117.55,89.36 117.92,88.99 v1(117.97,88.99)
  IN3 w0.117: v1(62.68,96.75) 62.94,96.49 62.94,96.28 63.15,96.07 81.67,96.07 81.79,95.95 81.79,95.61 82.03,95.37 82.56,95.37 82.8,95.61 82.8,96.22 82.91,96.34 83.27,96.34 83.38,96.22 83.38,95.61 83.62,95.37 84.15,95.37 84.39,95.61 84.39,96.22 84.5,96.34 84.97,96.34 85.08,96.22 85.08,96.18 85.32,95.94 85.85,95.94 86.09,96.18 86.09,96.22 86.21,96.34 106.45,96.34 108.49,94.29 112.3,94.29 112.68,93.91
  BOTTOM w0.089: UC1.H30 v1(117.97,88.99)
  BOTTOM w0.112: JDIMM2.55 65.42,96.49 65.28,96.63 65.04,96.63 64.51,96.1 63.14,96.1 62.9,96.34 62.9,96.53 v1(62.68,96.75)
DDR_B_DQS3: length 67.2
  IN3 w0.089: v1(117.97,86.26) 117.97,86.55 117.89,86.62 116.25,86.62 115.76,87.12 114,87.12 111.33,89.78 107.36,89.78 105.63,91.51 105.62,91.51 105.6,91.53
  IN3 w0.117: 105.6,91.53 104.89,92.24 87.75,92.24 85.72,90.21 66.69,90.21 66.45,90.45 66.45,90.79 66.34,90.91 65.99,90.91 65.87,90.79 65.87,90.45 65.63,90.21 64.22,90.21 63.98,90.45 63.98,90.79 63.86,90.91 63.51,90.91 63.4,90.79 63.4,90.45 63.16,90.21 61.73,90.21 61.37,90.57 61.37,90.92 v1(61.11,91.17)
  BOTTOM w0.089: UC1.N30 v1(117.97,86.26)
  BOTTOM w0.112: JDIMM2.76 59.28,91.24 59.42,91.38 59.79,91.38 60.07,91.66 61.25,91.66 61.38,91.53 61.38,91.44 v1(61.11,91.17)
DDR_B_DQS4: length 67.3
  IN3 w0.089: 102.56,71.91 102.57,71.91 102.58,71.92 102.64,71.92 102.66,71.94 105.18,71.94 105.52,72.28 112.91,72.28 115.41,74.78 117.28,74.78 117.45,74.78 117.65,74.99 117.65,75.08 v1(117.92,75.35)
  IN3 w0.117: v1(62.66,63.37) 62.66,62.47 62.94,62.18 78.08,62.18 78.71,62.81 83.7,62.81 85.32,64.44 88.41,64.44 90.02,66.05 95.84,66.05 101.7,71.91 102.56,71.91
  BOTTOM w0.102: UC1.AL30 118.21,75.06 v1(117.92,75.35)
  BOTTOM w0.112: JDIMM2.179 65.42,63.49 65.28,63.63 65.13,63.63 65.01,63.52 65.01,63.09 64.63,62.7 63.12,62.7 62.93,62.89 62.93,63.1 v1(62.66,63.37)
DDR_B_DQS5: length 68.2
  IN3 w0.089: v1(117.96,71.69) 117.79,71.51 117.79,71.28 117.63,71.12 116.47,71.12 115.92,70.57 115.09,70.57 113.98,69.46 113.98,68.87 113.6,68.49 113.06,68.49 112.73,68.82 105.39,68.82 105.15,68.58 104.9,68.58 104.89,68.56
  IN3 w0.117: 104.89,68.56 103.75,68.56 103.26,68.07 103.26,68.07 97.48,62.29 92.85,62.29 91.3,60.74 87.74,60.74 84.51,57.51 63.24,57.51 63.08,57.35 61.54,57.35 61.31,57.57 61.31,57.79 v1(61.14,57.97)
  BOTTOM w0.089: v1(117.96,71.69) UC1.AU30
  BOTTOM w0.112: JDIMM2.200 59.28,58.24 59.42,58.38 61.29,58.38 61.4,58.27 61.4,58.08 61.29,57.97 v1(61.14,57.97)
DDR_B_DQS6: length 67.9
  IN3 w0.089: 106.29,64.87 106.3,64.89 106.3,64.9 106.71,65.3 110.79,65.3 111.12,65.63 112.78,65.63 113,65.41 113.68,65.41 113.84,65.41 115.89,67.45 117.57,67.45 117.77,67.65 117.77,67.79 v1(118.02,68.04)
  IN3 w0.117: 106.29,64.87 99.5,58.09 97.69,58.09 94.9,55.3 87.53,55.3 84.36,52.13 67.34,52.13 67.05,52.43 66.12,52.43 65.82,52.13 64.89,52.13 64.35,52.66 63.17,52.66 63.05,52.55 63.05,52.38 63.18,52.25 v1(63.42,52.25)
  BOTTOM w0.102: UC1.BC30 v1(118.02,68.04)
  BOTTOM w0.112: JDIMM2.221 65.42,52.99 65.14,53.27 63.37,53.27 63.15,53.05 63.15,52.52 v1(63.42,52.25)
DDR_B_DQS7: length 69.2
  IN3 w0.089: v1(117.97,64.38) 117.8,64.21 117.8,64.03 117.6,63.83 116.84,63.83 116.84,63.84 116.33,63.84 115.91,63.42 115.58,63.42 114.24,62.08 114.24,61.63 112.73,60.12 111.28,60.12 111.16,60
  IN3 w0.117: 111.16,60 110.57,59.41 109.97,59.41 106.17,55.61 103.21,55.61 100.09,52.49 97.46,52.49 95.3,50.33 88.28,50.33 84.77,46.82 61.61,46.82 61.37,47.06 61.37,47.31 61.23,47.45 v1(61.14,47.45)
  BOTTOM w0.076: UC1.BH30 v1(117.97,64.38)
  BOTTOM w0.112: JDIMM2.242 59.28,47.74 59.42,47.88 61.32,47.88 61.43,47.77 61.43,47.61 61.27,47.45 v1(61.14,47.45)
DDR_B_DQS#0: length 80.2
  IN3 w0.089: 116.92,98.85 116.92,98.71 117.51,98.11 117.51,95.2 118.54,94.17 118.54,93.07 118.78,92.83 119.58,92.83 122.34,90.07 122.34,88.65 122.14,88.45 121.63,88.45 v1(121.62,88.44)
  IN3 w0.117: v1(61.19,102.07) 61.31,102.2 61.31,102.65 61.55,102.89 67.52,102.89 67.67,102.74 78.45,102.74 78.69,102.5 78.69,102.37 78.81,102.25 79.34,102.25 79.45,102.37 79.45,102.5 79.69,102.74 110.05,102.74 111.52,104.21 114.96,104.21 116.89,102.28 116.89,99.34 116.92,99.31 116.92,98.85
  BOTTOM w0.076: v1(121.62,88.44) 121.77,88.44 UC1.H24
  BOTTOM w0.112: JDIMM2.32 59.28,102.24 59.42,102.1 59.67,102.1 60.23,101.53 61.38,101.53 61.5,101.66 61.5,101.82 61.25,102.07 v1(61.19,102.07)
DDR_B_DQS#1: length 81.5
  IN3 w0.117: v1(62.66,107.26) 62.85,107.44 62.85,107.67 63.09,107.91 72.81,107.91 73.05,107.67 73.05,107.64 73.16,107.52 73.52,107.52 73.63,107.64 73.63,107.67 73.87,107.91 77.51,107.91 77.75,107.67 77.75,107.52 77.87,107.4 78.22,107.4 78.34,107.52 78.34,107.67 78.58,107.91 80.51,107.91 81.55,106.87 87.81,106.87 88.85,107.91 116.58,107.91 123.41,101.08 123.41,94.94 123.17,94.7 122.84,94.7 v1(122.7,94.57)
  BOTTOM w0.076: v1(122.7,94.57) 122.7,94.72 122.63,94.8 122.4,94.8 122.28,94.69 122.28,93.82 122.48,93.62 122.48,92.47 122.44,92.38 122.44,92.18 122.48,92.08 122.48,91.87 UC1.C23
  BOTTOM w0.112: JDIMM2.11 65.56,107.49 65.44,107.37 65.22,107.37 64.35,108.23 63.22,108.23 62.95,107.96 62.95,107.55 v1(62.66,107.26)
DDR_B_DQS#2: length 67.8
  IN3 w0.089: v1(117.97,89.9) 118.1,89.77 118.1,89.49 118.01,89.4 117.78,89.4 117.63,89.55 115.72,89.55 114.51,90.76 114.51,91.12 113.19,92.44 113.19,93.7 112.98,93.91
  IN3 w0.117: v1(63.45,96.75) 63.15,96.45 63.15,96.37 63.24,96.28 81.76,96.28 82,96.04 82,95.7 82.12,95.58 82.47,95.58 82.59,95.7 82.59,96.31 82.83,96.55 83.35,96.55 83.59,96.31 83.59,95.7 83.71,95.58 84.06,95.58 84.18,95.7 84.18,96.31 84.42,96.55 85.05,96.55 85.29,96.31 85.29,96.27 85.41,96.15 85.76,96.15 85.88,96.27 85.88,96.31 86.12,96.55 106.54,96.55 108.58,94.5 112.39,94.5 112.98,93.91
  BOTTOM w0.089: UC1.G30 v1(117.97,89.9)
  BOTTOM w0.112: JDIMM2.53 65.42,96.99 65.28,96.85 64.95,96.85 64.42,96.32 63.23,96.32 63.12,96.44 63.12,96.64 63.23,96.75 v1(63.45,96.75)
DDR_B_DQS#3: length 67.3
  IN3 w0.089: 105.75,91.68 105.77,91.66 105.77,91.65 107.44,89.97 111.41,89.97 114.08,87.31 115.84,87.31 116.35,86.8 117.9,86.8 117.97,86.86 v1(117.97,87.17)
  IN3 w0.117: 105.75,91.68 104.98,92.45 87.66,92.45 85.63,90.42 66.78,90.42 66.67,90.54 66.67,90.88 66.43,91.12 65.9,91.12 65.66,90.88 65.66,90.54 65.54,90.42 64.31,90.42 64.19,90.54 64.19,90.88 63.95,91.12 63.43,91.12 63.19,90.88 63.19,90.54 63.07,90.42 61.82,90.42 61.58,90.66 61.58,90.88 v1(61.87,91.17)
  BOTTOM w0.102: UC1.L30 v1(117.97,87.17)
  BOTTOM w0.112: v1(61.87,91.17) 61.63,91.42 61.63,91.59 61.34,91.88 59.98,91.88 59.7,91.6 59.42,91.6 59.28,91.74 JDIMM2.74
DDR_B_DQS#4: length 67.3
  IN3 w0.089: v1(117.29,75.35) 117.46,75.17 117.46,75.07 117.37,74.97 115.33,74.97 112.83,72.47 105.44,72.47 105.1,72.13 102.56,72.13
  IN3 w0.117: 102.56,72.13 102.56,72.13 101.61,72.13 100.32,70.84 100.32,70.83 95.75,66.26 89.93,66.26 88.32,64.65 85.24,64.65 83.61,63.02 78.62,63.02 77.99,62.39 63.03,62.39 62.87,62.55 62.87,62.77 62.96,62.86 63.67,62.86 63.79,62.98 63.79,63.25 63.67,63.37 v1(63.42,63.37)
  BOTTOM w0.102: v1(117.29,75.35) 117.56,75.07 UC1.AL31
  BOTTOM w0.112: JDIMM2.177 65.42,63.99 65.28,63.85 65.03,63.85 64.79,63.61 64.79,63.18 64.54,62.92 63.21,62.92 63.15,62.99 63.15,63.1 v1(63.42,63.37)
DDR_B_DQS#5: length 68.2
  IN3 w0.089: v1(117.32,71.7) 117.46,71.7 117.61,71.56 117.61,71.36 117.55,71.3 116.4,71.3 115.85,70.75 115.02,70.75 113.8,69.53 113.8,68.94 113.53,68.67 113.13,68.67 112.81,68.99 105.32,68.99 105.08,68.75 104.9,68.75 104.89,68.77
  IN3 w0.117: v1(61.9,57.97) 61.67,57.97 61.52,57.83 61.52,57.66 61.63,57.56 62.99,57.56 63.16,57.72 84.42,57.72 87.65,60.95 91.21,60.95 92.76,62.5 97.39,62.5 103.11,68.22 103.11,68.22 103.66,68.77 104.89,68.77
  BOTTOM w0.089: v1(117.32,71.7) UC1.AU31
  BOTTOM w0.112: JDIMM2.198 59.28,58.74 59.41,58.6 61.38,58.6 61.62,58.36 61.62,58.22 61.88,57.97 v1(61.9,57.97)
DDR_B_DQS#6: length 68
  IN3 w0.089: 106.14,65.02 106.15,65.04 106.17,65.04 106.63,65.49 110.71,65.49 111.04,65.82 112.85,65.82 113.08,65.6 113.76,65.6 115.81,67.65 117.49,67.65 117.58,67.73 117.58,67.87 117.42,68.03 v1(117.33,68.03)
  IN3 w0.117: v1(62.66,52.25) 62.84,52.43 62.84,52.63 63.08,52.87 64.44,52.87 64.97,52.34 65.73,52.34 66.03,52.64 67.13,52.64 67.43,52.34 84.27,52.34 87.44,55.51 94.81,55.51 97.6,58.3 99.42,58.3 106.14,65.02
  BOTTOM w0.102: v1(117.33,68.03) 117.33,68.03 UC1.BC31
  BOTTOM w0.112: v1(62.66,52.25) 62.93,52.52 62.93,53.14 63.28,53.49 JDIMM2.219
DDR_B_DQS#7: length 69.2
  IN3 w0.089: v1(117.32,64.41) 117.54,64.41 117.61,64.34 117.61,64.11 117.52,64.02 116.92,64.02 116.92,64.03 116.25,64.03 115.83,63.61 115.5,63.61 114.05,62.16 114.05,61.71 112.65,60.31 111.2,60.31 111.09,60.2 111.08,60.2 111.04,60.16 111.02,60.16 111.01,60.15
  IN3 w0.117: 111.01,60.15 110.49,59.62 109.88,59.62 106.08,55.82 103.12,55.82 100,52.7 97.37,52.7 95.21,50.54 88.19,50.54 84.68,47.03 61.69,47.03 61.58,47.15 61.58,47.32 61.71,47.45 v1(61.9,47.45)
  BOTTOM w0.076: UC1.BH31 v1(117.32,64.41)
  BOTTOM w0.112: v1(61.9,47.45) 61.81,47.45 61.65,47.61 61.65,47.86 61.41,48.1 59.42,48.1 59.28,48.24 JDIMM2.240
DDR_B_MA0: length 66.7
  IN3 w0.142: v1(104.43,79.06) 103.83,79.67 103.02,79.67 101.63,81.07 97.52,81.07 97.32,80.86 90.12,80.86 87,77.74 81.81,77.74 80.68,76.61 77.64,76.61 77.44,76.82 72.55,76.82 72.35,76.61 70.08,76.61 69.72,76.25 61.29,76.25 60.54,75.5 58.28,75.5 58.14,75.35 58.14,73.86 58.28,73.72 58.63,73.72 58.77,73.86 58.77,74.59 58.96,74.78 v1(59.79,74.78)
  BOTTOM w0.076: UC1.AG36 114.51,77.21 114.03,76.94 113.76,76.94 113.57,77.14 113.12,77.14 112.97,77 112.88,77 110.7,77 110,77.69 106.45,77.69
  BOTTOM w0.14: 106.45,77.69 105.8,77.69 v1(104.43,79.06) ; JDIMM2.144 59.25,74.24 v1(59.79,74.78)
DDR_B_MA1: length 69
  IN3 w0.089: 105.44,79.73 105.44,79.65 105.66,79.43 105.94,79.43 106.25,79.73 106.44,79.73 106.63,79.54 106.63,79.35 v1(106.34,79.06)
  IN3 w0.142: 105.44,79.73 105.14,80.03 104.94,80.03 104.79,79.87 104.59,79.87 104.39,80.07 104.39,80.28 104.54,80.43 104.54,80.63 104.37,80.8 103.05,80.8 101.97,81.88 89.98,81.88 87.56,79.46 82.38,79.46 80.55,77.63 79.83,77.63 79.69,77.78 79.69,78.14 79.55,78.28 79.26,78.28 79.12,78.14 79.12,77.78 78.98,77.63 78.69,77.63 78.55,77.78 78.55,78.14 78.41,78.28 78.12,78.28 77.98,78.14 77.98,77.78 77.84,77.63 72.02,77.63 71.88,77.78 71.88,78.14 71.74,78.28 71.45,78.28 71.31,78.14 71.31,77.78 71.17,77.63 70.88,77.63 70.74,77.78 70.74,78.14 70.6,78.28 70.31,78.28 70.17,78.14 70.17,77.78 70.03,77.63 69.3,77.63 69.12,77.81 69.12,78.14 68.98,78.28 68.69,78.28 68.55,78.14 68.55,77.8 68.38,77.63 63.77,77.63 63.35,77.21 62.9,77.21 62.56,77.56 62.35,77.56 62.06,77.26 62.06,77.06 v1(62.31,76.8)
  BOTTOM w0.076: UC1.AG35 115.12,77.3 114.66,77.47 114.48,77.47 114.36,77.43 114.12,77.43 114.01,77.47 112.95,77.47 112.81,77.33 110.91,77.33 110.22,78.02 107.38,78.02 106.45,78.95
  BOTTOM w0.14: v1(62.31,76.8) 62.74,76.37 64.82,76.37 65.44,76.99 JDIMM2.133 ; 106.45,78.95 v1(106.34,79.06)
DDR_B_MA2: length 69.3
  IN3 w0.089: v1(106.97,79.06) 106.97,79.45 106.47,79.95 105.51,79.95 104.25,81.21 103.37,81.21
  IN3 w0.142: v1(60.79,76.8) 60.79,76.33 60.47,76 59.61,76 59.47,76.15 59.47,76.39 59.34,76.51 58.98,76.51 58.84,76.37 58.84,76.27 58.69,76.13 58.34,76.13 58.2,76.27 58.2,77.2 58.34,77.34 61.56,77.34 62.26,78.04 67.22,78.04 67.86,78.69 81.03,78.69 82.21,79.87 87.39,79.87 89.81,82.29 102.14,82.29 103.22,81.21 103.37,81.21
  BOTTOM w0.076: v1(106.97,79.06) 107.85,78.19 110.28,78.19 110.97,77.5 112.75,77.5 112.88,77.64 114.04,77.64 114.15,77.6 114.33,77.6 114.45,77.64 114.69,77.64 114.81,77.59 115.28,77.59 UC1.AF34
  BOTTOM w0.14: JDIMM2.132 60.35,77.24 v1(60.79,76.8)
DDR_B_MA3: length 68.9
  IN3 w0.142: v1(63.84,76.8) 63.8,76.83 63.8,77.08 63.94,77.22 65.23,77.22 65.37,77.08 65.37,76.8 65.51,76.66 65.79,76.66 65.94,76.8 65.94,77.08 66.08,77.22 66.36,77.22 66.51,77.08 66.51,76.8 66.65,76.66 66.93,76.66 67.07,76.8 67.07,77.08 67.22,77.22 68.34,77.22 68.49,77.08 68.49,76.8 68.63,76.66 68.92,76.66 69.06,76.8 69.06,77.08 69.2,77.22 70.1,77.22 70.3,77.02 70.67,77.02 70.87,77.22 71.24,77.22 71.44,77.02 71.81,77.02 72.01,77.22 78.1,77.22 78.3,77.02 78.67,77.02 78.87,77.22 79.24,77.22 79.44,77.02 79.81,77.02 80.01,77.22 80.72,77.22 82.54,79.05 82.75,79.05 82.89,78.91 82.89,78.29 83.03,78.15 83.32,78.15 83.46,78.29 83.46,78.91 83.6,79.05 83.88,79.05 84.03,78.91 84.03,78.29 84.17,78.15 84.45,78.15 84.6,78.29 84.6,78.91 84.74,79.05 85.01,79.05 85.15,78.91 85.15,78.29 85.29,78.15 85.58,78.15 85.72,78.29 85.72,78.91 85.86,79.05 86.18,79.05 86.32,78.91 86.32,78.29 86.46,78.15 86.75,78.15 86.89,78.29 86.89,78.91 87.03,79.05 87.73,79.05 90.15,81.47 90.45,81.47 90.65,81.27 91.02,81.27 91.22,81.47 91.58,81.47 91.79,81.27 92.15,81.27 92.36,81.47 92.72,81.47 92.93,81.27 93.29,81.27 93.49,81.47 93.86,81.47 94.06,81.27 94.43,81.27 94.63,81.47 95,81.47 95.2,81.27 95.57,81.27 95.77,81.47 96.14,81.47 96.34,81.27 96.71,81.27 96.91,81.47 101.8,81.47 103.08,80.2 103.94,80.2 v1(105.07,79.06)
  BOTTOM w0.076: UC1.AG37 113.82,77.3 113.64,77.3 113.63,77.31 113.02,77.31 112.88,77.16 110.76,77.16 110.07,77.86 106.89,77.86 106.45,78.3
  BOTTOM w0.14: JDIMM2.131 64.53,77.49 63.98,78.04 63.47,78.04 63.16,77.73 63.16,77.47 v1(63.84,76.8) ; 106.45,78.3 106.29,78.46 105.67,78.46 105.59,78.54 v1(105.07,79.06)
DDR_B_MA4: length 68.4
  IN3 w0.089: 103.37,82.22 103.49,82.1 103.86,82.1 105.53,80.44 106.87,80.44 v1(108.24,79.06)
  IN3 w0.142: 103.37,82.22 102.48,83.11 89.47,83.11 87.05,80.69 81.87,80.69 80.69,79.51 67.53,79.51 66.88,78.86 61.92,78.86 61.22,78.16 58.91,78.16 58.77,78.3 58.77,78.69 58.91,78.83 60.92,78.83 61.38,79.29 v1(61.57,79.29)
  BOTTOM w0.076: UC1.AE35 114.95,78.24 114.48,78.24 114.36,78.29 114.12,78.29 114.01,78.24 112.99,78.24 112.82,78.41 112.37,78.41 111.8,77.84 111.1,77.84 110.42,78.52 108.78,78.52 v1(108.24,79.06)
  BOTTOM w0.14: JDIMM2.128 60.52,78.24 v1(61.57,79.29)
DDR_B_MA5: length 66.8
  IN3 w0.089: v1(107.61,79.06) 106.47,80.2 105.51,80.2 103.99,81.72 103.37,81.72
  IN3 w0.142: v1(60.05,79.29) 58.15,79.29 58.01,79.14 58.01,77.89 58.15,77.75 61.39,77.75 62.09,78.45 67.05,78.45 67.7,79.1 80.86,79.1 82.04,80.28 87.22,80.28 89.64,82.7 102.31,82.7 103.29,81.72 103.37,81.72
  BOTTOM w0.076: UC1.AF35 114.57,78.04 114.45,78.08 114.45,78.08 114.33,78.12 114.15,78.12 114.04,78.08 112.92,78.08 112.75,78.25 112.44,78.25 111.87,77.68 111.03,77.68 110.35,78.36 108.31,78.36 v1(107.61,79.06)
  BOTTOM w0.14: v1(60.05,79.29) 59.83,79.29 59.28,78.74 JDIMM2.126
DDR_B_MA6: length 68
  IN3 w0.089: v1(109.52,79.05) 109.93,79.46 109.93,79.74 109.84,79.83 107.73,79.83 107.64,79.92 107.64,80.1 107.73,80.19 109.72,80.19 109.81,80.28 109.81,80.49 109,81.3 105.11,81.3 103.61,82.8 103.37,82.8
  IN3 w0.142: 103.37,82.8 102.65,83.52 89.3,83.52 86.88,81.1 81.7,81.1 80.98,80.38 79.89,80.38 79.75,80.23 79.75,80.06 79.61,79.92 79.33,79.92 79.18,80.06 79.18,80.23 79.04,80.38 78.76,80.38 78.61,80.23 78.61,80.06 78.47,79.92 78.19,79.92 78.05,80.06 78.05,80.23 77.9,80.38 71.62,80.38 71.48,80.23 71.48,80.06 71.34,79.92 71.05,79.92 70.91,80.06 70.91,80.23 70.77,80.38 70.48,80.38 70.34,80.23 70.34,80.06 70.2,79.92 69.91,79.92 69.77,80.06 69.77,80.23 69.63,80.38 69.34,80.38 69.2,80.23 69.2,80.06 69.06,79.92 68.78,79.92 68.63,80.06 68.63,80.23 68.49,80.38 67.82,80.38 67.13,79.69 67.03,79.69 66.89,79.55 66.89,79.45 66.75,79.31 66.46,79.31 66.32,79.45 66.32,79.55 66.18,79.69 65.75,79.69 65.6,79.55 65.6,79.41 65.46,79.27 65.18,79.27 65.03,79.41 65.03,79.55 64.89,79.69 64.09,79.69 63.81,79.97 63.64,79.97 63.45,79.78 63.45,79.48 63.64,79.29 v1(63.86,79.29)
  BOTTOM w0.076: UC1.AE37 113.82,78.41 113.05,78.41 112.84,78.62 112.35,78.62 111.73,78.01 111.17,78.01 110.47,78.71 109.86,78.71 v1(109.52,79.05)
  BOTTOM w0.14: v1(63.86,79.29) 64.65,78.49 JDIMM2.127
DDR_B_MA7: length 67.5
  IN3 w0.089: v1(118.6,79.88) 118.49,79.88 118.11,80.26 115.03,80.26 114.46,80.83 110,80.83 109.12,81.71 105.61,81.71 105.19,82.14
  IN3 w0.142: v1(62.08,80.56) 62.5,80.99 65.98,80.99 66.18,81.19 69.62,81.19 70.49,82.07 77.58,82.07 77.72,81.93 77.72,81.34 77.86,81.19 79.15,81.19 79.29,81.34 79.29,81.93 79.44,82.07 86.7,82.07 88.97,84.34 94.05,84.34 94.19,84.48 94.19,84.63 94.33,84.77 94.62,84.77 94.76,84.63 94.76,84.48 94.9,84.34 95.19,84.34 95.33,84.48 95.33,84.63 95.47,84.77 95.76,84.77 95.9,84.63 95.9,84.48 96.04,84.34 96.33,84.34 96.47,84.48 96.47,84.63 96.61,84.77 102.55,84.77 105.19,82.14
  BOTTOM w0.089: UC1.AC29 v1(118.6,79.88)
  BOTTOM w0.14: JDIMM2.122 59.52,79.74 59.72,79.94 61.46,79.94 v1(62.08,80.56)
DDR_B_MA8: length 67.5
  IN3 w0.089: 103.53,83.21 105.27,81.47 109.07,81.47 110.15,80.4 v1(110.15,79.08)
  IN3 w0.142: v1(63.6,80.56) 63.8,80.56 64.26,80.1 64.6,80.1 64.75,80.24 64.75,80.44 64.89,80.58 65.17,80.58 65.31,80.44 65.31,80.24 65.46,80.1 65.83,80.1 65.97,80.24 65.97,80.44 66.11,80.58 66.4,80.58 66.54,80.44 66.54,80.24 66.68,80.1 66.96,80.1 67.65,80.79 70.41,80.79 70.55,80.93 70.55,81.52 70.69,81.66 70.98,81.66 71.12,81.52 71.12,80.93 71.26,80.79 71.54,80.79 71.69,80.93 71.69,81.52 71.83,81.66 72.11,81.66 72.26,81.52 72.26,80.93 72.4,80.79 72.89,80.79 73.03,80.93 73.03,81.07 73.17,81.22 73.46,81.22 73.6,81.07 73.6,80.93 73.74,80.79 74.02,80.79 74.17,80.93 74.17,81.07 74.31,81.22 74.59,81.22 74.74,81.07 74.74,80.93 74.88,80.79 75.16,80.79 75.31,80.93 75.31,81.07 75.45,81.22 75.73,81.22 75.87,81.07 75.87,80.93 76.02,80.79 76.3,80.79 76.44,80.93 76.44,81.07 76.59,81.22 76.87,81.22 77.01,81.07 77.01,80.93 77.15,80.79 79.56,80.79 79.7,80.93 79.7,81.52 79.84,81.66 80.13,81.66 80.27,81.52 80.27,80.93 80.41,80.79 80.81,80.79 81.53,81.51 86.71,81.51 89.14,83.93 91.85,83.93 91.86,83.93 102.82,83.93 103.53,83.21
  BOTTOM w0.076: v1(110.15,79.08) 110.33,79.08 111.23,78.17 111.65,78.17 112.27,78.79 112.91,78.79 113.12,78.58 113.57,78.58 113.76,78.77 114.03,78.77 114.45,78.54 114.51,78.51 UC1.AE36
  BOTTOM w0.14: JDIMM2.125 65.55,78.99 64.6,79.94 64.22,79.94 v1(63.6,80.56)
DDR_B_MA9: length 65.4
  IN3 w0.089: v1(118.6,80.79) 118.22,81.08 118.12,81.15 118.02,81.18 114.87,81.18 114.79,81.26 113.19,81.26 113.19,81.26 112.81,81.26 111.39,81.9 110.88,82.26 109.83,82.78 109.06,82.92 106.84,83.01 106.18,83.01
  IN3 w0.142: 106.18,83.01 105.47,83.01 102.71,85.77 94.18,85.77 93.56,85.16 88.63,85.16 86.36,82.89 66.72,82.89 65.64,81.8 62.76,81.8 v1(62.33,82.23)
  BOTTOM w0.089: UC1.AB29 v1(118.6,80.79)
  BOTTOM w0.14: JDIMM2.121 65.62,79.99 64.61,81 63.56,81 v1(62.33,82.23)
DDR_B_MA10: length 68.4
  IN3 w0.089: 100.87,76.76 101.08,76.55 108.58,76.55 v1(109.12,77.09)
  IN3 w0.142: v1(60.74,72.34) 60.74,72.85 60.6,72.99 58.51,72.99 58.36,72.85 58.36,71.96 58.51,71.81 61.31,71.81 61.37,71.87 82.36,71.87 83.59,73.1 89.4,73.1 93.61,77.31 100.32,77.31 100.87,76.76
  BOTTOM w0.076: v1(109.12,77.09) 109.56,77.53 109.89,77.53 110.59,76.83 112.81,76.83 113.04,76.83 113.19,76.98 113.5,76.98 113.69,76.78 114.07,76.78 114.3,76.9 115.24,76.9 UC1.AG34
  BOTTOM w0.14: JDIMM2.146 59.01,71.74 59.34,72.07 59.34,72.58 59.6,72.83 60.25,72.83 v1(60.74,72.34)
DDR_B_MA11: length 68.5
  IN3 w0.089: 105.57,82.33 105.8,82.1 109.13,82.1 110.15,81.08 114.72,81.08 115.36,80.44 118.14,80.44 118.76,80.23 v1(119.24,79.88)
  IN3 w0.142: 105.57,82.33 102.63,85.27 94.26,85.27 93.73,84.75 88.8,84.75 86.53,82.48 66.89,82.48 65.81,81.4 60.11,81.4 60.02,81.49 59.68,81.49 59.41,81.21 59.41,80.66 59.55,80.51 60.51,80.51 v1(60.55,80.56)
  BOTTOM w0.089: v1(119.24,79.88) UC1.AC28
  BOTTOM w0.14: JDIMM2.120 59.01,80.24 59.33,80.56 v1(60.55,80.56)
DDR_B_MA12: length 67.2
  IN3 w0.089: 107.22,83.51 107.47,83.51 107.72,83.26 110.33,83.26 111.57,82.02 114.85,82.02 115.52,81.35 118.29,81.35 118.43,81.21 118.81,81.21 v1(119.24,80.79)
  IN3 w0.142: 107.22,83.51 105.55,83.51 102.78,86.28 92.68,86.28 92.54,86.13 92.54,85.71 92.4,85.56 92.12,85.56 91.97,85.71 91.97,86.13 91.83,86.28 91.55,86.28 91.4,86.13 91.4,85.71 91.26,85.56 90.98,85.56 90.84,85.71 90.84,86.13 90.69,86.28 90.41,86.28 90.27,86.13 90.27,85.71 90.12,85.56 89.84,85.56 89.7,85.71 89.7,86.13 89.56,86.28 89.17,86.28 86.19,83.3 66.46,83.3 65.39,82.23 64.86,82.23 64.74,82.35 64.74,82.62 64.6,82.77 64.06,82.77 63.92,82.62 63.92,82.29 v1(63.86,82.23)
  BOTTOM w0.089: UC1.AB28 v1(119.24,80.79)
  BOTTOM w0.14: JDIMM2.119 65.69,80.49 63.95,82.23 v1(63.86,82.23)
DDR_B_MA13: length 69.3
  IN3 w0.089: 105.05,74.34 108.99,74.34 109.45,74.8 111.22,74.8 v1(112.04,75.63)
  IN3 w0.142: 105.05,74.34 104.43,73.72 100.49,73.72 99.37,72.59 98.96,72.59 94.74,68.38 89.05,68.38 87.44,66.77 84.36,66.77 83.17,65.58 59.42,65.58 59.28,65.73 59.28,67.23 59.42,67.37 61,67.37 v1(61.57,66.8)
  BOTTOM w0.076: UC1.AK35 114.71,75.16 114.57,75.16 114.45,75.12 114.45,75.12 114.34,75.08 114.14,75.08 114.04,75.12 112.91,75.12 112.76,74.97 112.46,74.97 112.04,75.39 v1(112.04,75.63)
  BOTTOM w0.14: v1(61.57,66.8) 61.57,67.9 61.45,68.02 59.73,68.02 59.02,68.74 JDIMM2.158
DDR_B_ODT0: length 69.7
  IN3 w0.089: v1(108.87,75.63) 108.24,75 106.68,75 106.57,75.12 104.3,75.12 104.05,74.86 100.07,74.86 99.75,74.55 99.22,74.55
  IN3 w0.142: 99.22,74.55 97.8,74.55 93.59,70.33 87.69,70.33 87.54,70.19 87.54,69.63 87.4,69.49 87.12,69.49 86.98,69.63 86.98,70.19 86.83,70.33 86.55,70.33 86.41,70.19 86.41,68.86 86.26,68.72 85.98,68.72 85.84,68.86 85.84,70.19 85.7,70.33 85.16,70.33 84.65,69.83 84.65,69.62 85.15,69.12 85.15,68.92 84.95,68.72 84.75,68.72 84.25,69.22 84.05,69.22 83.06,68.23 62.02,68.23 61.87,68.37 61.87,68.8 62.02,68.94 62.21,68.94 v1(62.33,69.06)
  BOTTOM w0.076: UC1.AL36 114.46,74.58 114.31,74.58 114.23,74.54 114.23,74.54 114.03,74.43 113.76,74.43 113.58,74.62 113.11,74.62 112.99,74.5 112.97,74.48 112.25,74.48 111.84,74.89 109.2,74.89 108.87,75.22 v1(108.87,75.63)
  BOTTOM w0.14: JDIMM2.155 62.75,69.49 62.2,70.03 62.01,70.03 61.76,69.79 61.76,69.59 62.28,69.06 v1(62.33,69.06)
DDR_B_ODT1: length 70.2
  IN3 w0.089: 99.22,73.24 99.51,73.24 100.61,74.35 101.14,74.35 101.23,74.26 101.23,74.01 101.32,73.92 101.5,73.92 101.59,74.01 101.59,74.26 101.68,74.35 101.86,74.35 101.94,74.26 101.94,74.01 102.03,73.92 102.21,73.92 102.3,74.01 102.3,74.26 102.39,74.35 104.42,74.35 104.68,74.61 106.55,74.61 106.61,74.55 108.84,74.55 109.4,75.11 111.27,75.11 111.41,75.24 v1(111.41,75.63)
  IN3 w0.142: v1(63.09,66.8) 62.9,66.8 62.65,66.55 62.65,66.35 62.77,66.23 65.14,66.23 65.28,66.38 65.28,66.79 65.43,66.93 65.71,66.93 65.85,66.79 65.85,66.38 65.99,66.23 66.28,66.23 66.42,66.38 66.42,66.79 66.56,66.93 66.85,66.93 66.99,66.79 66.99,66.38 67.13,66.23 70.18,66.23 70.32,66.38 70.32,66.79 70.46,66.93 70.75,66.93 70.89,66.79 70.89,66.38 71.03,66.23 71.32,66.23 71.46,66.38 71.46,66.79 71.6,66.93 71.89,66.93 72.03,66.79 72.03,66.38 72.17,66.23 77.79,66.23 77.93,66.38 77.93,66.79 78.07,66.93 78.36,66.93 78.5,66.79 78.5,66.38 78.64,66.23 78.93,66.23 79.07,66.38 79.07,66.79 79.21,66.93 79.49,66.93 79.64,66.79 79.64,66.38 79.78,66.23 82.9,66.23 84.09,67.42 87.17,67.42 88.78,69.03 94.48,69.03 98.69,73.24 99.22,73.24
  BOTTOM w0.076: v1(111.41,75.63) 111.79,75.24 111.95,75.24 112.39,74.81 112.83,74.81 112.97,74.95 112.98,74.95 112.99,74.95 114.01,74.95 114.12,74.91 114.36,74.91 114.48,74.95 115.6,74.95 UC1.AL34
  BOTTOM w0.14: JDIMM2.161 65.72,67.99 65.33,67.6 63.89,67.6 v1(63.09,66.8)
DDR_B_PAR: length 65.1
  IN3 w0.089: 101.74,77.63 101.84,77.53 103.16,77.53 103.46,77.83 110.78,77.83 v1(111.51,78.56)
  IN3 w0.142: v1(68.11,73.51) 70.23,73.51 70.31,73.59 82.34,73.59 83.08,74.33 87.24,74.33 87.39,74.47 87.39,74.85 87.53,74.99 87.81,74.99 87.96,74.85 87.96,74.47 88.1,74.33 88.89,74.33 89.08,74.52 89.08,74.72 88.27,75.53 88.27,75.73 88.47,75.93 88.67,75.93 89.48,75.12 89.68,75.12 89.88,75.32 89.88,75.53 89.07,76.33 89.07,76.53 89.28,76.74 89.48,76.74 90.28,75.93 90.49,75.93 90.69,76.13 90.69,76.33 89.88,77.14 89.88,77.34 90.08,77.54 90.28,77.54 91.09,76.73 91.29,76.73 91.49,76.93 91.49,77.13 90.68,77.94 90.68,78.14 90.88,78.34 91.09,78.34 91.89,77.54 92.09,77.54 92.31,77.76 92.31,77.96 92.1,78.17 92.1,78.4 92.24,78.54 100.82,78.54 101.74,77.63
  BOTTOM w0.076: UC1.AE34 115.66,78.51 115.35,78.82 114.29,78.82 114.07,78.94 113.69,78.94 113.5,78.75 113.19,78.75 112.97,78.97 111.92,78.97 v1(111.51,78.56)
  BOTTOM w0.14: JDIMM2.143 67.34,74.49 68.11,73.72 v1(68.11,73.51)
DDR_B_RAS#: length 68.6
  IN3 w0.089: v1(109.76,77.09) 109.03,76.36 103.44,76.36 103.36,76.28 100.77,76.28 100.41,76.64
  IN3 w0.142: v1(60.81,70.78) 60.25,70.23 58.9,70.23 58.64,70.48 58.64,71.18 58.87,71.4 61.48,71.4 61.54,71.46 82.53,71.46 83.76,72.69 89.56,72.69 93.78,76.91 100.15,76.91 100.41,76.64
  BOTTOM w0.076: v1(109.76,77.09) 110.19,76.67 112.75,76.67 113.19,76.23 113.51,76.23 113.69,76.42 114.07,76.42 114.31,76.29 115.25,76.29 115.51,76.17 115.69,76.17 UC1.AJ34
  BOTTOM w0.14: v1(60.81,70.78) 60.81,70.36 61.22,69.95 61.22,69.65 61.06,69.49 59.89,69.49 59.14,70.24 JDIMM2.152
DDR_B_WE#: length 67.9
  IN3 w0.089: 99.22,75.6 99.75,75.6 99.86,75.5 103.67,75.5 103.83,75.67 v1(106.85,75.67)
  IN3 w0.142: v1(62.33,70.78) 62.33,70.43 62.19,70.29 60.89,70.29 60.7,70.1 60.7,69.74 60.84,69.59 82.5,69.59 84.3,71.39 90.1,71.39 92.11,73.39 93.49,73.39 94.83,74.74 94.83,75.46 94.97,75.6 95.21,75.6 95.35,75.46 95.35,74.92 95.91,74.35 96.11,74.35 96.31,74.55 96.31,74.75 95.92,75.15 95.92,75.46 96.07,75.6 96.27,75.6 96.72,75.16 96.92,75.16 97.37,75.6 99.22,75.6
  BOTTOM w0.076: UC1.AJ35 115.15,75.99 114.92,75.77 114.77,75.77 114.66,75.73 114.48,75.73 114.36,75.77 114.12,75.77 114.01,75.73 112.99,75.73 112.55,76.16 107.35,76.16 v1(106.85,75.67)
  BOTTOM w0.14: JDIMM2.151 65.25,70.49 64.9,70.14 62.98,70.14 v1(62.33,70.78)
DDR_DRAMRST#: length 129.2
  TOP w0.112: RD8.2 RD9.2 69.1,81.91 v1(69,81.81)
  IN1 w0.119: v1(59.98,82.1) 60.52,82.65 68.16,82.65 v1(69,81.81)
  IN3 w0.135: v1(59.98,82.1) 59.95,82.13 59.41,82.13 58.71,81.43 58.71,80.76 57.36,79.41 57.36,77.48 57.42,77.42 57.42,72.07 57.72,71.77 57.72,71.69 58,71.41 58,70.21 58.12,70.09 57.69,69.67 57.69,69.18 57.76,69.11 57.76,57.52 58.07,57.21 58.07,55.05 57.82,54.8 57.82,53.53 57.37,53.08 55.53,53.08 54.2,51.75 54.2,47.09 55.85,45.44 55.85,44.25 57.25,42.86 58.77,42.86 59.85,41.78 61.06,41.78 61.5,41.33 63.53,41.33 64.42,40.44 65.31,40.44 65.57,40.7 68.55,40.7 69,40.25 74.46,40.25 75.66,39.05 77.57,39.05 80.82,42.3 80.82,42.3 82.7,44.18 85.13,44.18 89.16,48.22 98.82,48.22 99.05,47.98 102.32,47.98 102.88,47.41 107.5,47.41 109.94,49.86 109.94,51.36 112.95,54.37 114.21,54.37 116.43,56.59 116.81,56.59 117.11,56.89 v1(117.3,57.08)
  BOTTOM w0.076: v1(117.3,57.08) 117.26,57.12 117.26,57.82 117.56,58.13 UC1.BU31
DDR_DRAMRST#_R: length 17.6
  TOP w0.112: v1(68.36,81.81) 68.51,81.96 RD9.1 67.69,82.86 CD26.1 66.39,82.89 66.26,83.01 v2(58.2,83.01) 57.15,83.01 v1(56.92,83.24)
  BOTTOM w0.102: JDIMM2.108 58.25,83.24
  BOTTOM w0.112: JDIMM1.108 69.48,83.24 68.36,82.12 v1(68.36,81.81) ; 58.25,83.24 v1(56.92,83.24)
DDR_VTT_CNTL: length 20
  TOP w0.112: UC2.2 106.46,105.09 106.97,104.58 v2(107.07,104.58) v1(108.65,104.58)
  BOTTOM w0.102: 113.84,93.56 113.84,93.01 114.04,92.8 114.04,92.5 114.23,92.3 114.23,91.85 114.39,91.69 114.85,91.69 UC1.C35
  BOTTOM w0.112: 113.84,93.56 113.84,94.28 111.54,96.58 111.19,96.58 108.76,99.02 108.76,104.47 v1(108.65,104.58)
DGPU_HOLD_RST#: length 239.5
  TOP w0.112: v1(90.36,118.68) v2(89.73,118.68)
  IN2 w0.124: v1(55.66,125.28) 55.42,125.04 52.88,125.04 42.89,115.05 42.89,113.34 41.62,112.07 41.62,103.78 47.76,97.64 47.76,94.29 45.82,92.35 45.82,87.31 45.5,86.99 45.5,81.54 45.16,81.2 45.16,77.36 46.38,76.14 46.38,71.03 46.65,70.76 46.65,67.62 50.49,63.78 50.49,57.81 52.07,56.23 52.07,48.08 54.19,45.96 54.19,43.08 56.32,40.95 58.45,40.95 61.86,37.54 71.12,37.54 71.71,38.14 75.99,38.14 76.28,37.84 78.59,37.84 81.02,40.28 81.97,40.28 82.64,40.95 90.9,40.95 91.34,41.39 93.78,41.39 94.4,42.01 107.71,42.01 110.99,45.29 111.85,45.29 112.58,46.01 114.2,46.01 115.2,47.02 116.55,47.02 117.61,48.08 120.56,48.08 120.68,47.95 120.68,47.11 120.81,46.98 122.1,46.98 122.6,46.48 122.6,45.99 122.81,45.78 v1(123.15,45.78)
  IN3 w0.135: v1(90.36,118.68) 88.37,118.68 86.41,120.63 78.49,120.63 77.23,121.9 69.63,121.9 69.25,122.28 60.24,122.28 59.53,122.99 56.93,122.99 56.49,123.44 56.49,124.46 v1(55.66,125.28)
  BOTTOM w0.076: UC1.CR22 123.36,47.7 123.39,47.67 123.39,46.07 123.15,45.83 v1(123.15,45.78) 123.1,45.72 123.1,45.41 123.48,45.03 RC107.1
  BOTTOM w0.112: v1(90.36,118.68) 90.87,119.18 91.47,119.18 91.91,119.62 93.17,119.62 93.6,119.18 97.2,119.18 100.57,115.82 105.25,115.82 108.75,119.31 UV2.2
DGPU_PWR_EN: length 338.4
  TOP w0.112: v1(122.53,109.72) 122.55,109.72 123.87,111.04 v3(130.32,111.04) 134.97,111.04 138.32,114.39 v1(138.32,115.11) ; v1(67.94,129.34) PRV15.1
  IN1 w0.119: v1(138.32,115.11) 136.32,115.11 127.92,123.5 124.51,123.5 122.6,121.6 122.6,119.61 124.76,117.45 124.76,116.72 124.46,116.42 114.75,116.42 112.25,118.93 94.24,118.93 v1(94.06,118.75) ; v1(121.32,45.61) 121,45.61 120.3,44.92 120.3,42.54 121,41.85 v1(121,40.69)
  IN2 w0.124: v1(94.06,118.75) 93.35,118.04 92.62,118.04 90.71,116.14 85.75,116.14 85.37,116.52 69,116.52 68.11,117.41 68.11,121.34 64.17,125.28 64.17,126.17 64.55,126.55 66.96,126.55 67.85,127.44 69.38,127.44 69.92,127.99 69.92,128.67 69.25,129.34 v1(67.94,129.34) 67.94,130.46 67.15,131.25 59.47,131.25 58.04,129.82 58.04,127.92 56.99,126.87 55.09,126.87 53.82,125.6 52.65,125.6 42.33,115.28 42.33,113.57 41.06,112.3 41.06,94.95 43.04,92.97 43.04,86.72 43.82,85.94 43.82,84.44 43.06,83.68 43.06,76.15 43.45,75.76 43.45,72.34 44.32,71.47 44.32,70.83 44.14,70.65 44.14,69.05 44.79,68.4 44.79,66.5 46.8,64.49 46.8,61.56 48.75,59.62 48.75,56.62 50.29,55.08 50.29,47.61 51.04,46.86 51.04,41.93 52.5,40.48 54.18,40.48 55.55,39.1 58.01,39.1 61.16,35.95 68.12,35.95 68.44,35.64 78.62,35.64 81.64,38.65 84.31,38.65 84.79,38.17 94.23,38.17 94.37,38.03 98.05,38.03 99.78,36.3 114.31,36.3 118.01,40 120.29,40 120.98,40.69 v1(121,40.69)
  BOTTOM w0.076: 121.81,47.03 121.81,49.35 122.14,49.69 UC1.CM24
  BOTTOM w0.089: 121.81,47.03 121.19,46.41 121.19,46.06 121.32,45.93 v1(121.32,45.61)
  BOTTOM w0.112: RC114.2 121.07,40.91 121,40.84 v1(121,40.69) 121,40.68 RC116.2 ; RZ5.1 v1(138.32,115.11) ; v1(122.53,109.72) 122.46,109.66 122.46,108.14 122.14,107.82 121.71,107.82 RZ6.1 121.07,106.15 121.07,105.15 120.81,104.9 117.95,104.9 117,105.85 RZ7.1
